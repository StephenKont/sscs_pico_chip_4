* NGSPICE file created from user_analog_project_wrapper.ext - technology: sky130A

.subckt sky130_fd_pr__res_xhigh_po_5p73_2AHZHE a_669_4504# a_n1815_n4936# a_n1945_n5066#
X0 a_n1815_n4936# a_669_4504# a_n1945_n5066# sky130_fd_pr__res_xhigh_po w=5.73e+06u l=1.2254e+08u
.ends

.subckt sky130_fd_pr__nfet_01v8_SBZDCA a_n81_n588# a_63_n500# a_n33_n500# a_15_522#
+ a_n227_n674# a_n125_n500#
X0 a_n33_n500# a_n81_n588# a_n125_n500# a_n227_n674# sky130_fd_pr__nfet_01v8 ad=1.65e+12p pd=1.066e+07u as=1.55e+12p ps=1.062e+07u w=5e+06u l=150000u
X1 a_63_n500# a_15_522# a_n33_n500# a_n227_n674# sky130_fd_pr__nfet_01v8 ad=1.55e+12p pd=1.062e+07u as=0p ps=0u w=5e+06u l=150000u
.ends

.subckt sky130_fd_pr__nfet_01v8_UBS3CQ a_n125_n138# a_n183_n50# a_n285_n224# a_125_n50#
X0 a_125_n50# a_n125_n138# a_n183_n50# a_n285_n224# sky130_fd_pr__nfet_01v8 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=1.25e+06u
.ends

.subckt sky130_fd_pr__nfet_01v8_lvt_9G3FLA a_159_n100# a_111_n188# a_15_122# a_n273_n188#
+ a_255_n100# a_n611_n274# a_351_n100# a_n417_n100# a_207_122# a_n129_n100# a_n81_n188#
+ a_63_n100# a_n177_122# a_n225_n100# a_n321_n100# a_n369_122# a_n33_n100# a_n509_n100#
+ a_303_n188# a_n465_n188# a_447_n100# a_399_122#
X0 a_63_n100# a_15_122# a_n33_n100# a_n611_n274# sky130_fd_pr__nfet_01v8_lvt ad=3.3e+11p pd=2.66e+06u as=3.3e+11p ps=2.66e+06u w=1e+06u l=150000u
X1 a_n33_n100# a_n81_n188# a_n129_n100# a_n611_n274# sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=3.3e+11p ps=2.66e+06u w=1e+06u l=150000u
X2 a_351_n100# a_303_n188# a_255_n100# a_n611_n274# sky130_fd_pr__nfet_01v8_lvt ad=3.3e+11p pd=2.66e+06u as=3.3e+11p ps=2.66e+06u w=1e+06u l=150000u
X3 a_159_n100# a_111_n188# a_63_n100# a_n611_n274# sky130_fd_pr__nfet_01v8_lvt ad=3.3e+11p pd=2.66e+06u as=0p ps=0u w=1e+06u l=150000u
X4 a_255_n100# a_207_122# a_159_n100# a_n611_n274# sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X5 a_447_n100# a_399_122# a_351_n100# a_n611_n274# sky130_fd_pr__nfet_01v8_lvt ad=3.1e+11p pd=2.62e+06u as=0p ps=0u w=1e+06u l=150000u
X6 a_n321_n100# a_n369_122# a_n417_n100# a_n611_n274# sky130_fd_pr__nfet_01v8_lvt ad=3.3e+11p pd=2.66e+06u as=3.3e+11p ps=2.66e+06u w=1e+06u l=150000u
X7 a_n417_n100# a_n465_n188# a_n509_n100# a_n611_n274# sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=3.1e+11p ps=2.62e+06u w=1e+06u l=150000u
X8 a_n225_n100# a_n273_n188# a_n321_n100# a_n611_n274# sky130_fd_pr__nfet_01v8_lvt ad=3.3e+11p pd=2.66e+06u as=0p ps=0u w=1e+06u l=150000u
X9 a_n129_n100# a_n177_122# a_n225_n100# a_n611_n274# sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
.ends

.subckt sky130_fd_sc_hs__dfrtp_4 CLK D RESET_B VGND VPWR Q VNB VPB
X0 VPWR CLK a_313_74# VPB sky130_fd_pr__pfet_01v8 ad=3.172e+12p pd=2.426e+07u as=3.248e+11p ps=2.82e+06u w=1.12e+06u l=150000u
X1 VGND RESET_B a_124_78# VNB sky130_fd_pr__nfet_01v8_lvt ad=2.1303e+12p pd=1.722e+07u as=1.008e+11p ps=1.32e+06u w=420000u l=150000u
X2 a_494_366# a_313_74# VGND VNB sky130_fd_pr__nfet_01v8_lvt ad=2.109e+11p pd=2.05e+06u as=0p ps=0u w=740000u l=150000u
X3 a_37_78# D VPWR VPB sky130_fd_pr__pfet_01v8 ad=2.478e+11p pd=2.86e+06u as=0p ps=0u w=420000u l=150000u
X4 a_834_355# a_699_463# VGND VNB sky130_fd_pr__nfet_01v8_lvt ad=9.435e+11p pd=4.03e+06u as=0p ps=0u w=740000u l=150000u
X5 VPWR a_2010_409# Q VPB sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=7.224e+11p ps=5.77e+06u w=1.12e+06u l=150000u
X6 a_1647_81# a_313_74# a_1350_392# VNB sky130_fd_pr__nfet_01v8_lvt ad=1.008e+11p pd=1.32e+06u as=4.58e+11p ps=3.28e+06u w=420000u l=150000u
X7 VPWR a_1678_395# a_1627_493# VPB sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=1.134e+11p ps=1.38e+06u w=420000u l=150000u
X8 VPWR a_1350_392# a_1678_395# VPB sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=1.26e+11p ps=1.44e+06u w=420000u l=150000u
X9 VGND CLK a_313_74# VNB sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=2.109e+11p ps=2.05e+06u w=740000u l=150000u
X10 a_1627_493# a_494_366# a_1350_392# VPB sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=6.724e+11p ps=4.47e+06u w=420000u l=150000u
X11 VGND RESET_B a_890_138# VNB sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=1.008e+11p ps=1.32e+06u w=420000u l=150000u
X12 a_699_463# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8 ad=2.478e+11p pd=2.86e+06u as=0p ps=0u w=420000u l=150000u
X13 a_1678_395# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X14 a_1827_81# RESET_B VGND VNB sky130_fd_pr__nfet_01v8_lvt ad=1.008e+11p pd=1.32e+06u as=0p ps=0u w=420000u l=150000u
X15 Q a_2010_409# VGND VNB sky130_fd_pr__nfet_01v8_lvt ad=4.847e+11p pd=4.27e+06u as=0p ps=0u w=740000u l=150000u
X16 a_1350_392# a_313_74# a_834_355# VPB sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=3e+11p ps=2.6e+06u w=1e+06u l=150000u
X17 a_890_138# a_834_355# a_812_138# VNB sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=1.008e+11p ps=1.32e+06u w=420000u l=150000u
X18 a_834_355# a_699_463# VPWR VPB sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X19 a_812_138# a_494_366# a_699_463# VNB sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=1.47e+11p ps=1.54e+06u w=420000u l=150000u
X20 Q a_2010_409# VGND VNB sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=740000u l=150000u
X21 VGND a_2010_409# Q VNB sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=740000u l=150000u
X22 VPWR a_1350_392# a_2010_409# VPB sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=2.52e+11p ps=2.28e+06u w=840000u l=150000u
X23 Q a_2010_409# VPWR VPB sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=1.12e+06u l=150000u
X24 VGND a_2010_409# Q VNB sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=740000u l=150000u
X25 VGND a_1678_395# a_1647_81# VNB sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X26 VPWR RESET_B a_37_78# VPB sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X27 VPWR a_834_355# a_789_463# VPB sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=1.008e+11p ps=1.32e+06u w=420000u l=150000u
X28 a_1678_395# a_1350_392# a_1827_81# VNB sky130_fd_pr__nfet_01v8_lvt ad=1.197e+11p pd=1.41e+06u as=0p ps=0u w=420000u l=150000u
X29 a_1350_392# a_494_366# a_834_355# VNB sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=740000u l=150000u
X30 a_124_78# D a_37_78# VNB sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=2.394e+11p ps=2.82e+06u w=420000u l=150000u
X31 a_699_463# a_313_74# a_37_78# VNB sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X32 a_789_463# a_313_74# a_699_463# VPB sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X33 a_2010_409# a_1350_392# VPWR VPB sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=840000u l=150000u
X34 VPWR a_2010_409# Q VPB sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=1.12e+06u l=150000u
X35 a_699_463# a_494_366# a_37_78# VPB sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=420000u l=150000u
X36 Q a_2010_409# VPWR VPB sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=1.12e+06u l=150000u
X37 a_494_366# a_313_74# VPWR VPB sky130_fd_pr__pfet_01v8 ad=3.192e+11p pd=2.81e+06u as=0p ps=0u w=1.12e+06u l=150000u
X38 a_2010_409# a_1350_392# VGND VNB sky130_fd_pr__nfet_01v8_lvt ad=2.109e+11p pd=2.05e+06u as=0p ps=0u w=740000u l=150000u
.ends

.subckt sky130_fd_sc_hs__nand3_1 A B C VGND VPWR Y VNB VPB
X0 a_233_74# B a_155_74# VNB sky130_fd_pr__nfet_01v8_lvt ad=3.108e+11p pd=2.32e+06u as=1.776e+11p ps=1.96e+06u w=740000u l=150000u
X1 VPWR B Y VPB sky130_fd_pr__pfet_01v8 ad=8.904e+11p pd=6.07e+06u as=6.664e+11p ps=5.67e+06u w=1.12e+06u l=150000u
X2 Y C VPWR VPB sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=1.12e+06u l=150000u
X3 Y A VPWR VPB sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=1.12e+06u l=150000u
X4 a_155_74# C VGND VNB sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=2.109e+11p ps=2.05e+06u w=740000u l=150000u
X5 Y A a_233_74# VNB sky130_fd_pr__nfet_01v8_lvt ad=2.109e+11p pd=2.05e+06u as=0p ps=0u w=740000u l=150000u
.ends

.subckt sky130_fd_pr__pfet_g5v0d10v5_AJQB7U a_n50_n197# a_50_n100# w_n308_n397# a_n108_n100#
X0 a_50_n100# a_n50_n197# a_n108_n100# w_n308_n397# sky130_fd_pr__pfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
.ends

.subckt sky130_fd_pr__res_xhigh_po_0p35_RJUBBE a_n35_165# a_n35_n597# a_n165_n727#
X0 a_n35_n597# a_n35_165# a_n165_n727# sky130_fd_pr__res_xhigh_po_0p35 l=1.65e+06u
.ends

.subckt sky130_fd_sc_hs__inv_16 A VGND VPWR Y VNB VPB
X0 Y A VPWR VPB sky130_fd_pr__pfet_01v8 ad=2.7216e+12p pd=2.278e+07u as=3.4272e+12p ps=2.628e+07u w=1.12e+06u l=150000u
X1 Y A VPWR VPB sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=1.12e+06u l=150000u
X2 VPWR A Y VPB sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=1.12e+06u l=150000u
X3 Y A VPWR VPB sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=1.12e+06u l=150000u
X4 Y A VGND VNB sky130_fd_pr__nfet_01v8_lvt ad=1.6576e+12p pd=1.632e+07u as=2.2718e+12p ps=1.946e+07u w=740000u l=150000u
X5 VGND A Y VNB sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=740000u l=150000u
X6 Y A VPWR VPB sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=1.12e+06u l=150000u
X7 VGND A Y VNB sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=740000u l=150000u
X8 VPWR A Y VPB sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=1.12e+06u l=150000u
X9 VPWR A Y VPB sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=1.12e+06u l=150000u
X10 Y A VPWR VPB sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=1.12e+06u l=150000u
X11 Y A VGND VNB sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=740000u l=150000u
X12 VGND A Y VNB sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=740000u l=150000u
X13 VGND A Y VNB sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=740000u l=150000u
X14 VPWR A Y VPB sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=1.12e+06u l=150000u
X15 Y A VGND VNB sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=740000u l=150000u
X16 Y A VPWR VPB sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=1.12e+06u l=150000u
X17 VGND A Y VNB sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=740000u l=150000u
X18 VPWR A Y VPB sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=1.12e+06u l=150000u
X19 Y A VGND VNB sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=740000u l=150000u
X20 VPWR A Y VPB sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=1.12e+06u l=150000u
X21 Y A VPWR VPB sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=1.12e+06u l=150000u
X22 VPWR A Y VPB sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=1.12e+06u l=150000u
X23 VGND A Y VNB sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=740000u l=150000u
X24 Y A VPWR VPB sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=1.12e+06u l=150000u
X25 VGND A Y VNB sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=740000u l=150000u
X26 Y A VGND VNB sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=740000u l=150000u
X27 VGND A Y VNB sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=740000u l=150000u
X28 Y A VGND VNB sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=740000u l=150000u
X29 VPWR A Y VPB sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=1.12e+06u l=150000u
X30 Y A VGND VNB sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=740000u l=150000u
X31 Y A VGND VNB sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=740000u l=150000u
.ends

.subckt sky130_fd_pr__nfet_g5v0d10v5_RX3AJQ a_50_n100# a_n242_n322# a_n108_n100# a_n50_n188#
X0 a_50_n100# a_n50_n188# a_n108_n100# a_n242_n322# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
.ends

.subckt sky130_fd_pr__nfet_g5v0d10v5_KH736R a_2025_n400# a_4237_n400# a_1235_n400#
+ a_3447_n400# a_5659_n400# a_n287_n488# a_761_n400# a_n4079_n488# a_2657_n400# a_4869_n400#
+ a_819_n488# a_5185_n400# a_n1077_n488# a_n3289_n488# a_1867_n400# a_345_n488# a_2183_n400#
+ a_4395_n400# a_n29_n400# a_n2499_n488# a_1393_n400# a_n919_n488# a_977_n488# a_n5027_n488#
+ a_n6483_n622# a_3605_n400# a_5817_n400# a_n445_n488# a_6133_n400# a_3189_n488# a_n1709_n488#
+ a_n187_n400# a_n2025_n488# a_n4237_n488# a_2815_n400# a_3131_n400# a_5343_n400#
+ a_2399_n488# a_n1235_n488# a_n3447_n488# a_n5659_n488# a_n3189_n400# a_2341_n400#
+ a_503_n488# a_4553_n400# a_n2657_n488# a_n4869_n488# a_n2399_n400# a_n5185_n488#
+ a_1551_n400# a_3763_n400# a_5975_n400# a_1609_n488# a_4137_n488# a_n819_n400# a_6291_n400#
+ a_n1867_n488# a_n2183_n488# a_n4395_n488# a_2973_n400# a_1135_n488# a_n603_n488#
+ a_5559_n488# a_n345_n400# a_3347_n488# a_n1393_n488# a_n1609_n400# a_n4137_n400#
+ a_661_n488# a_4769_n488# a_n6349_n400# a_5501_n400# a_2557_n488# a_5085_n488# a_n3605_n488#
+ a_n5817_n488# a_n1135_n400# a_n6133_n488# a_n5559_n400# a_n3347_n400# a_4711_n400#
+ a_1767_n488# a_3979_n488# a_2083_n488# a_4295_n488# a_n977_n400# a_n2815_n488# a_n3131_n488#
+ a_n4769_n400# a_n2557_n400# a_n5343_n488# a_3921_n400# a_n761_n488# a_n5085_n400#
+ a_1293_n488# a_n1767_n400# a_n2341_n488# a_n4553_n488# a_n3979_n400# a_n4295_n400#
+ a_n2083_n400# a_3505_n488# a_5717_n488# a_n503_n400# a_n1551_n488# a_n3763_n488#
+ a_6033_n488# a_129_n400# a_n5975_n488# a_n1293_n400# a_n6291_n488# a_4927_n488#
+ a_2715_n488# a_5243_n488# a_3031_n488# a_n2973_n488# a_n3505_n400# a_n5717_n400#
+ a_1925_n488# a_n6033_n400# a_2241_n488# a_4453_n488# a_n5501_n488# a_n4927_n400#
+ a_n2715_n400# a_n5243_n400# a_n3031_n400# a_5875_n488# a_3663_n488# a_1451_n488#
+ a_6191_n488# a_n661_n400# a_n1925_n400# a_287_n400# a_n4711_n488# a_n2241_n400#
+ a_n4453_n400# a_2873_n488# a_n3921_n488# a_n5875_n400# a_n3663_n400# a_n1451_n400#
+ a_n6191_n400# a_5401_n488# a_n2873_n400# a_4611_n488# a_919_n400# a_n5401_n400#
+ a_3821_n488# a_445_n400# a_n4611_n400# a_n3821_n400# a_4079_n400# a_1077_n400# a_3289_n400#
+ a_29_n488# a_2499_n400# a_n129_n488# a_603_n400# a_187_n488# a_5027_n400# a_1709_n400#
X0 a_n5401_n400# a_n5501_n488# a_n5559_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X1 a_n2557_n400# a_n2657_n488# a_n2715_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X2 a_n503_n400# a_n603_n488# a_n661_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X3 a_2657_n400# a_2557_n488# a_2499_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X4 a_5501_n400# a_5401_n488# a_5343_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X5 a_n29_n400# a_n129_n488# a_n187_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X6 a_603_n400# a_503_n488# a_445_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X7 a_n4927_n400# a_n5027_n488# a_n5085_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X8 a_n4453_n400# a_n4553_n488# a_n4611_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X9 a_4553_n400# a_4453_n488# a_4395_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X10 a_n3979_n400# a_n4079_n488# a_n4137_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X11 a_n1135_n400# a_n1235_n488# a_n1293_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X12 a_1235_n400# a_1135_n488# a_1077_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X13 a_n5559_n400# a_n5659_n488# a_n5717_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X14 a_n2715_n400# a_n2815_n488# a_n2873_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X15 a_2815_n400# a_2715_n488# a_2657_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X16 a_5659_n400# a_5559_n488# a_5501_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X17 a_3131_n400# a_3031_n488# a_2973_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X18 a_n3031_n400# a_n3131_n488# a_n3189_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X19 a_n4611_n400# a_n4711_n488# a_n4769_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X20 a_n1767_n400# a_n1867_n488# a_n1925_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X21 a_1867_n400# a_1767_n488# a_1709_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X22 a_4711_n400# a_4611_n488# a_4553_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X23 a_n2083_n400# a_n2183_n488# a_n2241_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X24 a_2183_n400# a_2083_n488# a_2025_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X25 a_n4137_n400# a_n4237_n488# a_n4295_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X26 a_n3663_n400# a_n3763_n488# a_n3821_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X27 a_3763_n400# a_3663_n488# a_3605_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X28 a_4237_n400# a_4137_n488# a_4079_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X29 a_n5717_n400# a_n5817_n488# a_n5875_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X30 a_n819_n400# a_n919_n488# a_n977_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X31 a_5817_n400# a_5717_n488# a_5659_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X32 a_n6033_n400# a_n6133_n488# a_n6191_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X33 a_n3189_n400# a_n3289_n488# a_n3347_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X34 a_n661_n400# a_n761_n488# a_n819_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X35 a_3289_n400# a_3189_n488# a_3131_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X36 a_6133_n400# a_6033_n488# a_5975_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X37 a_919_n400# a_819_n488# a_761_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X38 a_n4769_n400# a_n4869_n488# a_n4927_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X39 a_n187_n400# a_n287_n488# a_n345_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X40 a_761_n400# a_661_n488# a_603_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X41 a_2025_n400# a_1925_n488# a_1867_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X42 a_4869_n400# a_4769_n488# a_4711_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X43 a_n5085_n400# a_n5185_n488# a_n5243_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X44 a_n2241_n400# a_n2341_n488# a_n2399_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X45 a_2341_n400# a_2241_n488# a_2183_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X46 a_5185_n400# a_5085_n488# a_5027_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X47 a_n3821_n400# a_n3921_n488# a_n3979_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X48 a_287_n400# a_187_n488# a_129_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X49 a_3921_n400# a_3821_n488# a_3763_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X50 a_n1293_n400# a_n1393_n488# a_n1451_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X51 a_1393_n400# a_1293_n488# a_1235_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X52 a_n3347_n400# a_n3447_n488# a_n3505_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X53 a_2973_n400# a_2873_n488# a_2815_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X54 a_3447_n400# a_3347_n488# a_3289_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X55 a_n2873_n400# a_n2973_n488# a_n3031_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X56 a_5027_n400# a_4927_n488# a_4869_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X57 a_n5243_n400# a_n5343_n488# a_n5401_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X58 a_n2399_n400# a_n2499_n488# a_n2557_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X59 a_n345_n400# a_n445_n488# a_n503_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X60 a_2499_n400# a_2399_n488# a_2341_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X61 a_5343_n400# a_5243_n488# a_5185_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X62 a_129_n400# a_29_n488# a_n29_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X63 a_n1609_n400# a_n1709_n488# a_n1767_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X64 a_445_n400# a_345_n488# a_287_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X65 a_1709_n400# a_1609_n488# a_1551_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X66 a_4079_n400# a_3979_n488# a_3921_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X67 a_n4295_n400# a_n4395_n488# a_n4453_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X68 a_n1925_n400# a_n2025_n488# a_n2083_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X69 a_n1451_n400# a_n1551_n488# a_n1609_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X70 a_1551_n400# a_1451_n488# a_1393_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X71 a_4395_n400# a_4295_n488# a_4237_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X72 a_n5875_n400# a_n5975_n488# a_n6033_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X73 a_3605_n400# a_3505_n488# a_3447_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X74 a_5975_n400# a_5875_n488# a_5817_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X75 a_n3505_n400# a_n3605_n488# a_n3663_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X76 a_6291_n400# a_6191_n488# a_6133_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X77 a_n6191_n400# a_n6291_n488# a_n6349_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X78 a_n977_n400# a_n1077_n488# a_n1135_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X79 a_1077_n400# a_977_n488# a_919_n400# a_n6483_n622# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
.ends

.subckt sky130_fd_pr__cap_mim_m3_2_L4DLLG m4_n20156_n6250# c2_n20056_n6150#
X0 c2_n20056_n6150# m4_n20156_n6250# sky130_fd_pr__cap_mim_m3_2 l=3e+07u w=3.003e+07u
X1 c2_n20056_n6150# m4_n20156_n6250# sky130_fd_pr__cap_mim_m3_2 l=3e+07u w=3e+07u
X2 c2_n20056_n6150# m4_n20156_n6250# sky130_fd_pr__cap_mim_m3_2 l=3e+07u w=3e+07u
X3 c2_n20056_n6150# m4_n20156_n6250# sky130_fd_pr__cap_mim_m3_2 l=3e+07u w=3e+07u
X4 c2_n20056_n6150# m4_n20156_n6250# sky130_fd_pr__cap_mim_m3_2 l=3e+07u w=3.003e+07u
X5 c2_n20056_n6150# m4_n20156_n6250# sky130_fd_pr__cap_mim_m3_2 l=3e+07u w=3e+07u
X6 c2_n20056_n6150# m4_n20156_n6250# sky130_fd_pr__cap_mim_m3_2 l=3e+07u w=3e+07u
X7 c2_n20056_n6150# m4_n20156_n6250# sky130_fd_pr__cap_mim_m3_2 l=3e+07u w=3e+07u
X8 c2_n20056_n6150# m4_n20156_n6250# sky130_fd_pr__cap_mim_m3_2 l=3e+07u w=3e+07u
X9 c2_n20056_n6150# m4_n20156_n6250# sky130_fd_pr__cap_mim_m3_2 l=3e+07u w=3e+07u
X10 c2_n20056_n6150# m4_n20156_n6250# sky130_fd_pr__cap_mim_m3_2 l=3e+07u w=3e+07u
X11 c2_n20056_n6150# m4_n20156_n6250# sky130_fd_pr__cap_mim_m3_2 l=3e+07u w=3e+07u
.ends

.subckt sky130_fd_pr__nfet_01v8_lvt_R5S7KJ a_n129_n200# a_n81_n288# a_63_n200# a_n177_222#
+ a_n225_n200# a_n321_n200# a_n369_222# a_n33_n200# a_n509_n200# a_303_n288# a_n465_n288#
+ a_447_n200# a_399_222# a_159_n200# a_111_n288# a_15_222# a_n273_n288# a_255_n200#
+ a_n611_n374# a_351_n200# a_207_222# a_n417_n200#
X0 a_n33_n200# a_n81_n288# a_n129_n200# a_n611_n374# sky130_fd_pr__nfet_01v8_lvt ad=6.6e+11p pd=4.66e+06u as=6.6e+11p ps=4.66e+06u w=2e+06u l=150000u
X1 a_351_n200# a_303_n288# a_255_n200# a_n611_n374# sky130_fd_pr__nfet_01v8_lvt ad=6.6e+11p pd=4.66e+06u as=6.6e+11p ps=4.66e+06u w=2e+06u l=150000u
X2 a_255_n200# a_207_222# a_159_n200# a_n611_n374# sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=6.6e+11p ps=4.66e+06u w=2e+06u l=150000u
X3 a_n321_n200# a_n369_222# a_n417_n200# a_n611_n374# sky130_fd_pr__nfet_01v8_lvt ad=6.6e+11p pd=4.66e+06u as=6.6e+11p ps=4.66e+06u w=2e+06u l=150000u
X4 a_159_n200# a_111_n288# a_63_n200# a_n611_n374# sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=6.6e+11p ps=4.66e+06u w=2e+06u l=150000u
X5 a_n225_n200# a_n273_n288# a_n321_n200# a_n611_n374# sky130_fd_pr__nfet_01v8_lvt ad=6.6e+11p pd=4.66e+06u as=0p ps=0u w=2e+06u l=150000u
X6 a_447_n200# a_399_222# a_351_n200# a_n611_n374# sky130_fd_pr__nfet_01v8_lvt ad=6.2e+11p pd=4.62e+06u as=0p ps=0u w=2e+06u l=150000u
X7 a_63_n200# a_15_222# a_n33_n200# a_n611_n374# sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=2e+06u l=150000u
X8 a_n129_n200# a_n177_222# a_n225_n200# a_n611_n374# sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=2e+06u l=150000u
X9 a_n417_n200# a_n465_n288# a_n509_n200# a_n611_n374# sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=6.2e+11p ps=4.62e+06u w=2e+06u l=150000u
.ends

.subckt sky130_fd_pr__pfet_01v8_lvt_4YVKJ3 a_35_n144# a_n163_n241# a_221_n241# a_291_n144#
+ a_n221_n144# w_n487_n363# a_n35_n241# a_93_n241# a_n349_n144# a_163_n144# a_n291_n241#
+ a_n93_n144#
X0 a_163_n144# a_93_n241# a_35_n144# w_n487_n363# sky130_fd_pr__pfet_01v8_lvt ad=4.176e+11p pd=3.46e+06u as=4.176e+11p ps=3.46e+06u w=1.44e+06u l=350000u
X1 a_n93_n144# a_n163_n241# a_n221_n144# w_n487_n363# sky130_fd_pr__pfet_01v8_lvt ad=4.176e+11p pd=3.46e+06u as=4.176e+11p ps=3.46e+06u w=1.44e+06u l=350000u
X2 a_291_n144# a_221_n241# a_163_n144# w_n487_n363# sky130_fd_pr__pfet_01v8_lvt ad=4.176e+11p pd=3.46e+06u as=0p ps=0u w=1.44e+06u l=350000u
X3 a_n221_n144# a_n291_n241# a_n349_n144# w_n487_n363# sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=4.176e+11p ps=3.46e+06u w=1.44e+06u l=350000u
X4 a_35_n144# a_n35_n241# a_n93_n144# w_n487_n363# sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1.44e+06u l=350000u
.ends

.subckt sky130_fd_pr__pfet_01v8_lvt_MUFCUN a_483_n720# a_99_n720# a_n413_n720# a_n29_n720#
+ a_n483_n817# a_n99_n817# a_541_n817# a_157_n817# a_355_n720# a_n285_n720# a_n355_n817#
+ w_n807_n939# a_413_n817# a_29_n817# a_611_n720# a_227_n720# a_n541_n720# a_n157_n720#
+ a_n227_n817# a_n611_n817# a_285_n817# a_n669_n720#
X0 a_355_n720# a_285_n817# a_227_n720# w_n807_n939# sky130_fd_pr__pfet_01v8_lvt ad=2.088e+12p pd=1.498e+07u as=2.088e+12p ps=1.498e+07u w=7.2e+06u l=350000u
X1 a_483_n720# a_413_n817# a_355_n720# w_n807_n939# sky130_fd_pr__pfet_01v8_lvt ad=2.088e+12p pd=1.498e+07u as=0p ps=0u w=7.2e+06u l=350000u
X2 a_n29_n720# a_n99_n817# a_n157_n720# w_n807_n939# sky130_fd_pr__pfet_01v8_lvt ad=2.088e+12p pd=1.498e+07u as=2.088e+12p ps=1.498e+07u w=7.2e+06u l=350000u
X3 a_n413_n720# a_n483_n817# a_n541_n720# w_n807_n939# sky130_fd_pr__pfet_01v8_lvt ad=2.088e+12p pd=1.498e+07u as=2.088e+12p ps=1.498e+07u w=7.2e+06u l=350000u
X4 a_n541_n720# a_n611_n817# a_n669_n720# w_n807_n939# sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=2.088e+12p ps=1.498e+07u w=7.2e+06u l=350000u
X5 a_n157_n720# a_n227_n817# a_n285_n720# w_n807_n939# sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=2.088e+12p ps=1.498e+07u w=7.2e+06u l=350000u
X6 a_611_n720# a_541_n817# a_483_n720# w_n807_n939# sky130_fd_pr__pfet_01v8_lvt ad=2.088e+12p pd=1.498e+07u as=0p ps=0u w=7.2e+06u l=350000u
X7 a_227_n720# a_157_n817# a_99_n720# w_n807_n939# sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=2.088e+12p ps=1.498e+07u w=7.2e+06u l=350000u
X8 a_n285_n720# a_n355_n817# a_n413_n720# w_n807_n939# sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=7.2e+06u l=350000u
X9 a_99_n720# a_29_n817# a_n29_n720# w_n807_n939# sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=7.2e+06u l=350000u
.ends

.subckt sky130_fd_pr__cap_mim_m3_1_6ZNTNB c1_n1050_n1000# m3_n1150_n1100#
X0 c1_n1050_n1000# m3_n1150_n1100# sky130_fd_pr__cap_mim_m3_1 l=1e+07u w=1e+07u
.ends

.subckt sky130_fd_pr__nfet_01v8_lvt_46VND8 a_n371_n462# a_n81_n288# a_n33_n376# a_n269_n288#
+ a_159_n376# a_207_n288# a_63_310# a_15_n288# a_n129_310# a_n177_n288# a_111_n288#
+ a_n225_n376#
X0 a_n81_n288# a_n129_310# a_n177_n288# a_n371_n462# sky130_fd_pr__nfet_01v8_lvt ad=9.504e+11p pd=6.42e+06u as=9.504e+11p ps=6.42e+06u w=2.88e+06u l=150000u
X1 a_15_n288# a_n33_n376# a_n81_n288# a_n371_n462# sky130_fd_pr__nfet_01v8_lvt ad=9.504e+11p pd=6.42e+06u as=0p ps=0u w=2.88e+06u l=150000u
X2 a_n177_n288# a_n225_n376# a_n269_n288# a_n371_n462# sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=8.928e+11p ps=6.38e+06u w=2.88e+06u l=150000u
X3 a_207_n288# a_159_n376# a_111_n288# a_n371_n462# sky130_fd_pr__nfet_01v8_lvt ad=8.928e+11p pd=6.38e+06u as=9.504e+11p ps=6.42e+06u w=2.88e+06u l=150000u
X4 a_111_n288# a_63_310# a_15_n288# a_n371_n462# sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=2.88e+06u l=150000u
.ends

.subckt sky130_fd_pr__nfet_01v8_lvt_595QY5 a_n225_n188# a_207_n100# a_n371_n274# a_n33_n188#
+ a_15_n100# a_n177_n100# a_111_n100# a_159_n188# a_63_122# a_n81_n100# a_n129_122#
+ a_n269_n100#
X0 a_207_n100# a_159_n188# a_111_n100# a_n371_n274# sky130_fd_pr__nfet_01v8_lvt ad=3.1e+11p pd=2.62e+06u as=3.3e+11p ps=2.66e+06u w=1e+06u l=150000u
X1 a_15_n100# a_n33_n188# a_n81_n100# a_n371_n274# sky130_fd_pr__nfet_01v8_lvt ad=3.3e+11p pd=2.66e+06u as=3.3e+11p ps=2.66e+06u w=1e+06u l=150000u
X2 a_n81_n100# a_n129_122# a_n177_n100# a_n371_n274# sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=3.3e+11p ps=2.66e+06u w=1e+06u l=150000u
X3 a_111_n100# a_63_122# a_15_n100# a_n371_n274# sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=150000u
X4 a_n177_n100# a_n225_n188# a_n269_n100# a_n371_n274# sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=3.1e+11p ps=2.62e+06u w=1e+06u l=150000u
.ends

.subckt sky130_fd_pr__cap_mim_m3_2_6ZNTNB m4_n1350_n1100# c2_n1250_n1000#
X0 c2_n1250_n1000# m4_n1350_n1100# sky130_fd_pr__cap_mim_m3_2 l=1e+07u w=9.99e+06u
.ends

.subckt sky130_fd_pr__res_xhigh_po_0p35_NZJDJZ a_n35_164# a_n35_n596# a_n165_n726#
X0 a_n35_n596# a_n35_164# a_n165_n726# sky130_fd_pr__res_xhigh_po_0p35 l=1.64e+06u
.ends

.subckt opamp_small Inv NonInv Vdd Out Vss
Xsky130_fd_pr__pfet_01v8_lvt_4YVKJ3_0 m1_n265_940# m1_n265_940# m1_n265_940# m1_n265_940#
+ m1_n265_940# Vdd m1_n265_940# m1_n265_940# Vdd Vdd m1_n265_940# Vdd sky130_fd_pr__pfet_01v8_lvt_4YVKJ3
Xsky130_fd_pr__pfet_01v8_lvt_4YVKJ3_1 m1_989_28# m1_n265_940# m1_n265_940# m1_989_28#
+ m1_989_28# Vdd m1_n265_940# m1_n265_940# Vdd Vdd m1_n265_940# Vdd sky130_fd_pr__pfet_01v8_lvt_4YVKJ3
Xsky130_fd_pr__pfet_01v8_lvt_MUFCUN_1 Vdd Out Out Vdd m1_989_28# m1_989_28# m1_989_28#
+ m1_989_28# Out Vdd m1_989_28# Vdd m1_989_28# m1_989_28# Out Vdd Vdd Out m1_989_28#
+ m1_989_28# m1_989_28# Out sky130_fd_pr__pfet_01v8_lvt_MUFCUN
Xsky130_fd_pr__cap_mim_m3_1_6ZNTNB_0 Out m1_989_28# sky130_fd_pr__cap_mim_m3_1_6ZNTNB
Xsky130_fd_pr__nfet_01v8_lvt_46VND8_0 Vss Vss m1_n293_n600# Vss m1_n293_n600# Out
+ m1_n293_n600# Out m1_n293_n600# Out Vss m1_n293_n600# sky130_fd_pr__nfet_01v8_lvt_46VND8
Xsky130_fd_pr__nfet_01v8_lvt_46VND8_2 Vss m1_177_28# NonInv m1_177_28# NonInv m1_989_28#
+ NonInv m1_989_28# NonInv m1_989_28# m1_177_28# NonInv sky130_fd_pr__nfet_01v8_lvt_46VND8
Xsky130_fd_pr__nfet_01v8_lvt_46VND8_1 Vss m1_n265_940# Inv m1_n265_940# Inv m1_177_28#
+ Inv m1_177_28# Inv m1_177_28# m1_n265_940# Inv sky130_fd_pr__nfet_01v8_lvt_46VND8
Xsky130_fd_pr__nfet_01v8_lvt_595QY5_0 m1_n293_n600# Vss Vss m1_n293_n600# Vss Vss
+ m1_n293_n600# m1_n293_n600# m1_n293_n600# m1_n293_n600# m1_n293_n600# m1_n293_n600#
+ sky130_fd_pr__nfet_01v8_lvt_595QY5
Xsky130_fd_pr__nfet_01v8_lvt_595QY5_1 m1_n293_n600# Vss Vss m1_n293_n600# Vss Vss
+ m1_177_28# m1_n293_n600# m1_n293_n600# m1_177_28# m1_n293_n600# m1_177_28# sky130_fd_pr__nfet_01v8_lvt_595QY5
Xsky130_fd_pr__cap_mim_m3_2_6ZNTNB_0 Out m1_989_28# sky130_fd_pr__cap_mim_m3_2_6ZNTNB
Xsky130_fd_pr__res_xhigh_po_0p35_NZJDJZ_0 Vdd m1_n293_n600# Vss sky130_fd_pr__res_xhigh_po_0p35_NZJDJZ
.ends

.subckt sky130_fd_pr__pfet_01v8_lvt_C38N8W a_355_n500# a_n285_n500# w_n807_n719# a_n611_n597#
+ a_611_n500# a_227_n500# a_n541_n500# a_n157_n500# a_n669_n500# a_483_n500# a_99_n500#
+ a_n413_n500# a_n29_n500#
X0 a_227_n500# a_n611_n597# a_99_n500# w_n807_n719# sky130_fd_pr__pfet_01v8_lvt ad=1.45e+12p pd=1.058e+07u as=1.45e+12p ps=1.058e+07u w=5e+06u l=350000u
X1 a_n285_n500# a_n611_n597# a_n413_n500# w_n807_n719# sky130_fd_pr__pfet_01v8_lvt ad=1.45e+12p pd=1.058e+07u as=1.45e+12p ps=1.058e+07u w=5e+06u l=350000u
X2 a_99_n500# a_n611_n597# a_n29_n500# w_n807_n719# sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=1.45e+12p ps=1.058e+07u w=5e+06u l=350000u
X3 a_355_n500# a_n611_n597# a_227_n500# w_n807_n719# sky130_fd_pr__pfet_01v8_lvt ad=1.45e+12p pd=1.058e+07u as=0p ps=0u w=5e+06u l=350000u
X4 a_483_n500# a_n611_n597# a_355_n500# w_n807_n719# sky130_fd_pr__pfet_01v8_lvt ad=1.45e+12p pd=1.058e+07u as=0p ps=0u w=5e+06u l=350000u
X5 a_n29_n500# a_n611_n597# a_n157_n500# w_n807_n719# sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=1.45e+12p ps=1.058e+07u w=5e+06u l=350000u
X6 a_n413_n500# a_n611_n597# a_n541_n500# w_n807_n719# sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=1.45e+12p ps=1.058e+07u w=5e+06u l=350000u
X7 a_n541_n500# a_n611_n597# a_n669_n500# w_n807_n719# sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=1.45e+12p ps=1.058e+07u w=5e+06u l=350000u
X8 a_n157_n500# a_n611_n597# a_n285_n500# w_n807_n719# sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=5e+06u l=350000u
X9 a_611_n500# a_n611_n597# a_483_n500# w_n807_n719# sky130_fd_pr__pfet_01v8_lvt ad=1.45e+12p pd=1.058e+07u as=0p ps=0u w=5e+06u l=350000u
.ends

.subckt sky130_fd_pr__cap_mim_m3_1_L4DLLG c1_n18847_n6150# m3_n18947_n6250#
X0 c1_n18847_n6150# m3_n18947_n6250# sky130_fd_pr__cap_mim_m3_1 l=3e+07u w=3e+07u
X1 c1_n18847_n6150# m3_n18947_n6250# sky130_fd_pr__cap_mim_m3_1 l=3e+07u w=3e+07u
X2 c1_n18847_n6150# m3_n18947_n6250# sky130_fd_pr__cap_mim_m3_1 l=3e+07u w=3e+07u
X3 c1_n18847_n6150# m3_n18947_n6250# sky130_fd_pr__cap_mim_m3_1 l=3e+07u w=3e+07u
X4 c1_n18847_n6150# m3_n18947_n6250# sky130_fd_pr__cap_mim_m3_1 l=3e+07u w=3e+07u
X5 c1_n18847_n6150# m3_n18947_n6250# sky130_fd_pr__cap_mim_m3_1 l=3e+07u w=3e+07u
X6 c1_n18847_n6150# m3_n18947_n6250# sky130_fd_pr__cap_mim_m3_1 l=3e+07u w=3e+07u
X7 c1_n18847_n6150# m3_n18947_n6250# sky130_fd_pr__cap_mim_m3_1 l=3e+07u w=3e+07u
X8 c1_n18847_n6150# m3_n18947_n6250# sky130_fd_pr__cap_mim_m3_1 l=3e+07u w=3e+07u
X9 c1_n18847_n6150# m3_n18947_n6250# sky130_fd_pr__cap_mim_m3_1 l=3e+07u w=3e+07u
X10 c1_n18847_n6150# m3_n18947_n6250# sky130_fd_pr__cap_mim_m3_1 l=3e+07u w=3e+07u
X11 c1_n18847_n6150# m3_n18947_n6250# sky130_fd_pr__cap_mim_m3_1 l=3e+07u w=3e+07u
.ends

.subckt sky130_fd_pr__pfet_g5v0d10v5_5F54F3 a_2025_n400# a_4237_n400# a_n2341_n497#
+ a_n4553_n497# a_3505_n497# a_5717_n497# a_1235_n400# a_n1551_n497# a_n3763_n497#
+ a_6033_n497# a_3447_n400# a_5659_n400# a_n5975_n497# a_n6291_n497# a_4927_n497#
+ a_761_n400# a_2715_n497# a_5243_n497# a_2657_n400# a_4869_n400# a_3031_n497# a_n2973_n497#
+ a_5185_n400# a_1925_n497# a_1867_n400# a_2241_n497# a_4453_n497# a_2183_n400# a_4395_n400#
+ a_n5501_n497# a_n29_n400# a_5875_n497# a_3663_n497# a_1451_n497# a_1393_n400# a_6191_n497#
+ a_n4711_n497# a_2873_n497# a_3605_n400# a_n3921_n497# a_5817_n400# a_6133_n400#
+ a_n187_n400# a_5401_n497# a_2815_n400# a_3131_n400# a_5343_n400# a_4611_n497# a_n3189_n400#
+ a_2341_n400# a_4553_n400# a_n2399_n400# a_3821_n497# a_1551_n400# a_3763_n400# a_5975_n400#
+ a_n819_n400# a_6291_n400# a_2973_n400# a_n345_n400# a_n1609_n400# a_n4137_n400#
+ a_n6349_n400# a_5501_n400# a_n1135_n400# a_29_n497# a_n5559_n400# a_n3347_n400#
+ a_4711_n400# a_n977_n400# a_n129_n497# a_n4769_n400# a_n2557_n400# a_3921_n400#
+ a_n5085_n400# a_187_n497# a_n1767_n400# a_n3979_n400# a_n4295_n400# a_n2083_n400#
+ a_n503_n400# a_129_n400# a_n1293_n400# a_n287_n497# a_n3505_n400# a_n5717_n400#
+ a_n4079_n497# a_n6033_n400# a_819_n497# a_n4927_n400# a_n2715_n400# a_n1077_n497#
+ a_n3289_n497# a_n5243_n400# a_n3031_n400# a_345_n497# a_n661_n400# a_n1925_n400#
+ a_287_n400# a_n2241_n400# a_n2499_n497# a_n4453_n400# a_n919_n497# a_n5875_n400#
+ a_n3663_n400# a_n1451_n400# a_n6191_n400# a_n5027_n497# a_977_n497# a_n445_n497#
+ a_n2873_n400# a_3189_n497# a_n1709_n497# a_n2025_n497# a_n4237_n497# a_919_n400#
+ a_2399_n497# a_n1235_n497# a_n3447_n497# a_n5659_n497# a_n5401_n400# a_503_n497#
+ a_445_n400# a_n2657_n497# a_n4611_n400# a_n4869_n497# w_n6549_n697# a_n5185_n497#
+ a_1609_n497# a_4137_n497# a_n1867_n497# a_n3821_n400# a_n2183_n497# a_n4395_n497#
+ a_4079_n400# a_1135_n497# a_n603_n497# a_5559_n497# a_3347_n497# a_n1393_n497# a_1077_n400#
+ a_3289_n400# a_661_n497# a_4769_n497# a_2557_n497# a_2499_n400# a_5085_n497# a_n3605_n497#
+ a_n5817_n497# a_n6133_n497# a_1767_n497# a_3979_n497# a_603_n400# a_4295_n497# a_2083_n497#
+ a_n2815_n497# a_n3131_n497# a_5027_n400# a_n5343_n497# a_n761_n497# a_1293_n497#
+ a_1709_n400#
X0 a_n977_n400# a_n1077_n497# a_n1135_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X1 a_1077_n400# a_977_n497# a_919_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X2 a_n5401_n400# a_n5501_n497# a_n5559_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X3 a_n2557_n400# a_n2657_n497# a_n2715_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X4 a_n503_n400# a_n603_n497# a_n661_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X5 a_2657_n400# a_2557_n497# a_2499_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X6 a_5501_n400# a_5401_n497# a_5343_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X7 a_n29_n400# a_n129_n497# a_n187_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X8 a_603_n400# a_503_n497# a_445_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X9 a_n4927_n400# a_n5027_n497# a_n5085_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X10 a_n4453_n400# a_n4553_n497# a_n4611_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X11 a_4553_n400# a_4453_n497# a_4395_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X12 a_n3979_n400# a_n4079_n497# a_n4137_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X13 a_n1135_n400# a_n1235_n497# a_n1293_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X14 a_1235_n400# a_1135_n497# a_1077_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X15 a_n5559_n400# a_n5659_n497# a_n5717_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X16 a_n2715_n400# a_n2815_n497# a_n2873_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X17 a_2815_n400# a_2715_n497# a_2657_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X18 a_5659_n400# a_5559_n497# a_5501_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X19 a_n3031_n400# a_n3131_n497# a_n3189_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X20 a_3131_n400# a_3031_n497# a_2973_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X21 a_n4611_n400# a_n4711_n497# a_n4769_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X22 a_n1767_n400# a_n1867_n497# a_n1925_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X23 a_1867_n400# a_1767_n497# a_1709_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X24 a_4711_n400# a_4611_n497# a_4553_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X25 a_n2083_n400# a_n2183_n497# a_n2241_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X26 a_2183_n400# a_2083_n497# a_2025_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X27 a_4237_n400# a_4137_n497# a_4079_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X28 a_n4137_n400# a_n4237_n497# a_n4295_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X29 a_n3663_n400# a_n3763_n497# a_n3821_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X30 a_3763_n400# a_3663_n497# a_3605_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X31 a_n5717_n400# a_n5817_n497# a_n5875_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X32 a_n819_n400# a_n919_n497# a_n977_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X33 a_5817_n400# a_5717_n497# a_5659_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X34 a_n6033_n400# a_n6133_n497# a_n6191_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X35 a_n3189_n400# a_n3289_n497# a_n3347_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X36 a_n661_n400# a_n761_n497# a_n819_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X37 a_3289_n400# a_3189_n497# a_3131_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X38 a_6133_n400# a_6033_n497# a_5975_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X39 a_919_n400# a_819_n497# a_761_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X40 a_n4769_n400# a_n4869_n497# a_n4927_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X41 a_n187_n400# a_n287_n497# a_n345_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X42 a_761_n400# a_661_n497# a_603_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X43 a_2025_n400# a_1925_n497# a_1867_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X44 a_4869_n400# a_4769_n497# a_4711_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X45 a_n5085_n400# a_n5185_n497# a_n5243_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X46 a_n2241_n400# a_n2341_n497# a_n2399_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X47 a_2341_n400# a_2241_n497# a_2183_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X48 a_5185_n400# a_5085_n497# a_5027_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X49 a_n3821_n400# a_n3921_n497# a_n3979_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X50 a_287_n400# a_187_n497# a_129_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X51 a_3921_n400# a_3821_n497# a_3763_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X52 a_n1293_n400# a_n1393_n497# a_n1451_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X53 a_1393_n400# a_1293_n497# a_1235_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X54 a_n3347_n400# a_n3447_n497# a_n3505_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X55 a_n2873_n400# a_n2973_n497# a_n3031_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X56 a_2973_n400# a_2873_n497# a_2815_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X57 a_3447_n400# a_3347_n497# a_3289_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X58 a_n345_n400# a_n445_n497# a_n503_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X59 a_5027_n400# a_4927_n497# a_4869_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X60 a_n5243_n400# a_n5343_n497# a_n5401_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X61 a_n2399_n400# a_n2499_n497# a_n2557_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X62 a_2499_n400# a_2399_n497# a_2341_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X63 a_5343_n400# a_5243_n497# a_5185_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X64 a_129_n400# a_29_n497# a_n29_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X65 a_4079_n400# a_3979_n497# a_3921_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X66 a_n1609_n400# a_n1709_n497# a_n1767_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X67 a_445_n400# a_345_n497# a_287_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X68 a_1709_n400# a_1609_n497# a_1551_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X69 a_n4295_n400# a_n4395_n497# a_n4453_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X70 a_n1925_n400# a_n2025_n497# a_n2083_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X71 a_n1451_n400# a_n1551_n497# a_n1609_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X72 a_1551_n400# a_1451_n497# a_1393_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X73 a_4395_n400# a_4295_n497# a_4237_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X74 a_n5875_n400# a_n5975_n497# a_n6033_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X75 a_n3505_n400# a_n3605_n497# a_n3663_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X76 a_3605_n400# a_3505_n497# a_3447_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X77 a_5975_n400# a_5875_n497# a_5817_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X78 a_n6191_n400# a_n6291_n497# a_n6349_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X79 a_6291_n400# a_6191_n497# a_6133_n400# w_n6549_n697# sky130_fd_pr__pfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
.ends

.subckt switched_cap VPWR GND Vout Ref Control Power Clock
Xsky130_fd_pr__nfet_01v8_lvt_9G3FLA_3 m1_2444_n48551# sky130_fd_sc_hs__inv_16_6/A
+ sky130_fd_sc_hs__inv_16_6/A sky130_fd_sc_hs__inv_16_6/A GND GND m1_2444_n48551#
+ m1_2444_n48551# sky130_fd_sc_hs__inv_16_6/A GND sky130_fd_sc_hs__inv_16_6/A GND
+ sky130_fd_sc_hs__inv_16_6/A m1_2444_n48551# GND sky130_fd_sc_hs__inv_16_6/A m1_2444_n48551#
+ GND sky130_fd_sc_hs__inv_16_6/A sky130_fd_sc_hs__inv_16_6/A GND sky130_fd_sc_hs__inv_16_6/A
+ sky130_fd_pr__nfet_01v8_lvt_9G3FLA
Xsky130_fd_sc_hs__dfrtp_4_0 Clock sky130_fd_sc_hs__nand3_1_0/Y opamp_small_0/Out GND
+ VPWR sky130_fd_sc_hs__inv_16_0/A GND VPWR sky130_fd_sc_hs__dfrtp_4
Xsky130_fd_sc_hs__nand3_1_0 sky130_fd_sc_hs__inv_16_0/A sky130_fd_sc_hs__inv_16_1/A
+ sky130_fd_sc_hs__inv_16_4/A GND VPWR sky130_fd_sc_hs__nand3_1_0/Y GND VPWR sky130_fd_sc_hs__nand3_1
Xsky130_fd_sc_hs__dfrtp_4_1 Clock sky130_fd_sc_hs__inv_16_0/A opamp_small_0/Out GND
+ VPWR sky130_fd_sc_hs__inv_16_1/A GND VPWR sky130_fd_sc_hs__dfrtp_4
Xsky130_fd_sc_hs__dfrtp_4_2 Clock sky130_fd_sc_hs__inv_16_1/A opamp_small_0/Out GND
+ VPWR sky130_fd_sc_hs__inv_16_4/A GND VPWR sky130_fd_sc_hs__dfrtp_4
Xsky130_fd_sc_hs__dfrtp_4_3 Clock sky130_fd_sc_hs__inv_16_4/A opamp_small_0/Out GND
+ VPWR sky130_fd_sc_hs__inv_16_6/A GND VPWR sky130_fd_sc_hs__dfrtp_4
Xsky130_fd_pr__pfet_g5v0d10v5_AJQB7U_0 Control m1_19296_n808# Power Power sky130_fd_pr__pfet_g5v0d10v5_AJQB7U
Xsky130_fd_pr__res_xhigh_po_0p35_RJUBBE_0 Vout opamp_small_0/Inv GND sky130_fd_pr__res_xhigh_po_0p35_RJUBBE
Xsky130_fd_pr__res_xhigh_po_0p35_RJUBBE_1 opamp_small_0/Inv GND GND sky130_fd_pr__res_xhigh_po_0p35_RJUBBE
Xsky130_fd_sc_hs__inv_16_0 sky130_fd_sc_hs__inv_16_0/A GND VPWR sky130_fd_sc_hs__inv_16_0/Y
+ GND VPWR sky130_fd_sc_hs__inv_16
Xsky130_fd_pr__nfet_g5v0d10v5_RX3AJQ_0 m1_19296_n808# GND GND Control sky130_fd_pr__nfet_g5v0d10v5_RX3AJQ
Xsky130_fd_sc_hs__inv_16_1 sky130_fd_sc_hs__inv_16_1/A GND VPWR sky130_fd_sc_hs__inv_16_1/Y
+ GND VPWR sky130_fd_sc_hs__inv_16
Xsky130_fd_pr__nfet_g5v0d10v5_KH736R_0 Vout Vout m1_636_n48560# m1_636_n48560# m1_636_n48560#
+ Control Vout Control Vout Vout Control Vout Control Control m1_636_n48560# Control
+ m1_636_n48560# m1_636_n48560# m1_636_n48560# Control Vout Control Control Control
+ GND Vout Vout Control Vout Control Control Vout Control Control m1_636_n48560# m1_636_n48560#
+ m1_636_n48560# Control Control Control Control m1_636_n48560# Vout Control Vout
+ Control Control Vout Control m1_636_n48560# m1_636_n48560# m1_636_n48560# Control
+ Control Vout m1_636_n48560# Control Control Control Vout Control Control Control
+ m1_636_n48560# Control Control m1_636_n48560# m1_636_n48560# Control Control m1_636_n48560#
+ Vout Control Control Control Control Vout Control Vout Vout m1_636_n48560# Control
+ Control Control Control m1_636_n48560# Control Control m1_636_n48560# m1_636_n48560#
+ Control Vout Control m1_636_n48560# Control Vout Control Control Vout Vout Vout
+ Control Control Vout Control Control Control Vout Control m1_636_n48560# Control
+ Control Control Control Control Control m1_636_n48560# m1_636_n48560# Control m1_636_n48560#
+ Control Control Control Vout Vout Vout Vout Control Control Control Control m1_636_n48560#
+ m1_636_n48560# m1_636_n48560# Control m1_636_n48560# m1_636_n48560# Control Control
+ Vout Vout Vout Vout Control m1_636_n48560# Control m1_636_n48560# m1_636_n48560#
+ Control Vout Vout m1_636_n48560# m1_636_n48560# Vout Vout Control m1_636_n48560#
+ Control m1_636_n48560# Control m1_636_n48560# Vout sky130_fd_pr__nfet_g5v0d10v5_KH736R
Xsky130_fd_sc_hs__inv_16_4 sky130_fd_sc_hs__inv_16_4/A GND VPWR sky130_fd_sc_hs__inv_16_4/Y
+ GND VPWR sky130_fd_sc_hs__inv_16
Xsky130_fd_pr__cap_mim_m3_2_L4DLLG_0 m1_2444_n6551# m1_764_n6560# sky130_fd_pr__cap_mim_m3_2_L4DLLG
Xsky130_fd_pr__cap_mim_m3_2_L4DLLG_1 m1_2444_n20551# m1_764_n20560# sky130_fd_pr__cap_mim_m3_2_L4DLLG
Xsky130_fd_sc_hs__inv_16_6 sky130_fd_sc_hs__inv_16_6/A GND VPWR sky130_fd_sc_hs__inv_16_6/Y
+ GND VPWR sky130_fd_sc_hs__inv_16
Xsky130_fd_pr__cap_mim_m3_2_L4DLLG_2 m1_2444_n34551# m1_764_n34560# sky130_fd_pr__cap_mim_m3_2_L4DLLG
Xsky130_fd_pr__cap_mim_m3_2_L4DLLG_3 m1_2444_n48551# m1_764_n48560# sky130_fd_pr__cap_mim_m3_2_L4DLLG
Xsky130_fd_pr__nfet_01v8_lvt_R5S7KJ_0 VPWR sky130_fd_sc_hs__inv_16_0/Y VPWR sky130_fd_sc_hs__inv_16_0/Y
+ m1_2444_n6551# VPWR sky130_fd_sc_hs__inv_16_0/Y m1_2444_n6551# VPWR sky130_fd_sc_hs__inv_16_0/Y
+ sky130_fd_sc_hs__inv_16_0/Y VPWR sky130_fd_sc_hs__inv_16_0/Y m1_2444_n6551# sky130_fd_sc_hs__inv_16_0/Y
+ sky130_fd_sc_hs__inv_16_0/Y sky130_fd_sc_hs__inv_16_0/Y VPWR GND m1_2444_n6551#
+ sky130_fd_sc_hs__inv_16_0/Y m1_2444_n6551# sky130_fd_pr__nfet_01v8_lvt_R5S7KJ
Xopamp_small_0 opamp_small_0/Inv Ref VPWR opamp_small_0/Out GND opamp_small
Xsky130_fd_pr__nfet_01v8_lvt_R5S7KJ_1 VPWR sky130_fd_sc_hs__inv_16_1/Y VPWR sky130_fd_sc_hs__inv_16_1/Y
+ m1_2444_n20551# VPWR sky130_fd_sc_hs__inv_16_1/Y m1_2444_n20551# VPWR sky130_fd_sc_hs__inv_16_1/Y
+ sky130_fd_sc_hs__inv_16_1/Y VPWR sky130_fd_sc_hs__inv_16_1/Y m1_2444_n20551# sky130_fd_sc_hs__inv_16_1/Y
+ sky130_fd_sc_hs__inv_16_1/Y sky130_fd_sc_hs__inv_16_1/Y VPWR GND m1_2444_n20551#
+ sky130_fd_sc_hs__inv_16_1/Y m1_2444_n20551# sky130_fd_pr__nfet_01v8_lvt_R5S7KJ
Xsky130_fd_pr__nfet_01v8_lvt_R5S7KJ_2 VPWR sky130_fd_sc_hs__inv_16_4/Y VPWR sky130_fd_sc_hs__inv_16_4/Y
+ m1_2444_n34551# VPWR sky130_fd_sc_hs__inv_16_4/Y m1_2444_n34551# VPWR sky130_fd_sc_hs__inv_16_4/Y
+ sky130_fd_sc_hs__inv_16_4/Y VPWR sky130_fd_sc_hs__inv_16_4/Y m1_2444_n34551# sky130_fd_sc_hs__inv_16_4/Y
+ sky130_fd_sc_hs__inv_16_4/Y sky130_fd_sc_hs__inv_16_4/Y VPWR GND m1_2444_n34551#
+ sky130_fd_sc_hs__inv_16_4/Y m1_2444_n34551# sky130_fd_pr__nfet_01v8_lvt_R5S7KJ
Xsky130_fd_pr__nfet_01v8_lvt_R5S7KJ_3 VPWR sky130_fd_sc_hs__inv_16_6/Y VPWR sky130_fd_sc_hs__inv_16_6/Y
+ m1_2444_n48551# VPWR sky130_fd_sc_hs__inv_16_6/Y m1_2444_n48551# VPWR sky130_fd_sc_hs__inv_16_6/Y
+ sky130_fd_sc_hs__inv_16_6/Y VPWR sky130_fd_sc_hs__inv_16_6/Y m1_2444_n48551# sky130_fd_sc_hs__inv_16_6/Y
+ sky130_fd_sc_hs__inv_16_6/Y sky130_fd_sc_hs__inv_16_6/Y VPWR GND m1_2444_n48551#
+ sky130_fd_sc_hs__inv_16_6/Y m1_2444_n48551# sky130_fd_pr__nfet_01v8_lvt_R5S7KJ
Xsky130_fd_pr__pfet_01v8_lvt_C38N8W_0 VPWR m1_764_n6560# VPWR sky130_fd_sc_hs__inv_16_0/Y
+ VPWR m1_764_n6560# m1_764_n6560# VPWR VPWR m1_764_n6560# VPWR VPWR m1_764_n6560#
+ sky130_fd_pr__pfet_01v8_lvt_C38N8W
Xsky130_fd_pr__pfet_01v8_lvt_C38N8W_1 m1_636_n48560# m1_764_n6560# VPWR sky130_fd_sc_hs__inv_16_0/A
+ m1_636_n48560# m1_764_n6560# m1_764_n6560# m1_636_n48560# m1_636_n48560# m1_764_n6560#
+ m1_636_n48560# m1_636_n48560# m1_764_n6560# sky130_fd_pr__pfet_01v8_lvt_C38N8W
Xsky130_fd_pr__cap_mim_m3_1_L4DLLG_0 m1_2444_n6551# m1_764_n6560# sky130_fd_pr__cap_mim_m3_1_L4DLLG
Xsky130_fd_pr__pfet_g5v0d10v5_5F54F3_0 Vout Vout m1_19296_n808# m1_19296_n808# m1_19296_n808#
+ m1_19296_n808# m1_636_n48560# m1_19296_n808# m1_19296_n808# m1_19296_n808# m1_636_n48560#
+ m1_636_n48560# m1_19296_n808# m1_19296_n808# m1_19296_n808# Vout m1_19296_n808#
+ m1_19296_n808# Vout Vout m1_19296_n808# m1_19296_n808# Vout m1_19296_n808# m1_636_n48560#
+ m1_19296_n808# m1_19296_n808# m1_636_n48560# m1_636_n48560# m1_19296_n808# m1_636_n48560#
+ m1_19296_n808# m1_19296_n808# m1_19296_n808# Vout m1_19296_n808# m1_19296_n808#
+ m1_19296_n808# Vout m1_19296_n808# Vout Vout Vout m1_19296_n808# m1_636_n48560#
+ m1_636_n48560# m1_636_n48560# m1_19296_n808# m1_636_n48560# Vout Vout Vout m1_19296_n808#
+ m1_636_n48560# m1_636_n48560# m1_636_n48560# Vout m1_636_n48560# Vout m1_636_n48560#
+ m1_636_n48560# m1_636_n48560# m1_636_n48560# Vout Vout m1_19296_n808# Vout Vout
+ m1_636_n48560# m1_636_n48560# m1_19296_n808# m1_636_n48560# m1_636_n48560# Vout
+ m1_636_n48560# m1_19296_n808# Vout Vout Vout Vout Vout Vout m1_636_n48560# m1_19296_n808#
+ m1_636_n48560# m1_636_n48560# m1_19296_n808# m1_636_n48560# m1_19296_n808# Vout
+ Vout m1_19296_n808# m1_19296_n808# Vout Vout m1_19296_n808# m1_636_n48560# m1_636_n48560#
+ m1_636_n48560# m1_636_n48560# m1_19296_n808# m1_636_n48560# m1_19296_n808# Vout
+ Vout Vout Vout m1_19296_n808# m1_19296_n808# m1_19296_n808# m1_636_n48560# m1_19296_n808#
+ m1_19296_n808# m1_19296_n808# m1_19296_n808# m1_636_n48560# m1_19296_n808# m1_19296_n808#
+ m1_19296_n808# m1_19296_n808# m1_636_n48560# m1_19296_n808# Vout m1_19296_n808#
+ Vout m1_19296_n808# Power m1_19296_n808# m1_19296_n808# m1_19296_n808# m1_19296_n808#
+ m1_636_n48560# m1_19296_n808# m1_19296_n808# m1_636_n48560# m1_19296_n808# m1_19296_n808#
+ m1_19296_n808# m1_19296_n808# m1_19296_n808# Vout Vout m1_19296_n808# m1_19296_n808#
+ m1_19296_n808# m1_636_n48560# m1_19296_n808# m1_19296_n808# m1_19296_n808# m1_19296_n808#
+ m1_19296_n808# m1_19296_n808# m1_636_n48560# m1_19296_n808# m1_19296_n808# m1_19296_n808#
+ m1_19296_n808# m1_636_n48560# m1_19296_n808# m1_19296_n808# m1_19296_n808# Vout
+ sky130_fd_pr__pfet_g5v0d10v5_5F54F3
Xsky130_fd_pr__pfet_01v8_lvt_C38N8W_2 VPWR m1_764_n20560# VPWR sky130_fd_sc_hs__inv_16_1/Y
+ VPWR m1_764_n20560# m1_764_n20560# VPWR VPWR m1_764_n20560# VPWR VPWR m1_764_n20560#
+ sky130_fd_pr__pfet_01v8_lvt_C38N8W
Xsky130_fd_pr__cap_mim_m3_1_L4DLLG_1 m1_2444_n20551# m1_764_n20560# sky130_fd_pr__cap_mim_m3_1_L4DLLG
Xsky130_fd_pr__pfet_01v8_lvt_C38N8W_3 m1_636_n48560# m1_764_n20560# VPWR sky130_fd_sc_hs__inv_16_1/A
+ m1_636_n48560# m1_764_n20560# m1_764_n20560# m1_636_n48560# m1_636_n48560# m1_764_n20560#
+ m1_636_n48560# m1_636_n48560# m1_764_n20560# sky130_fd_pr__pfet_01v8_lvt_C38N8W
Xsky130_fd_pr__pfet_01v8_lvt_C38N8W_4 VPWR m1_764_n34560# VPWR sky130_fd_sc_hs__inv_16_4/Y
+ VPWR m1_764_n34560# m1_764_n34560# VPWR VPWR m1_764_n34560# VPWR VPWR m1_764_n34560#
+ sky130_fd_pr__pfet_01v8_lvt_C38N8W
Xsky130_fd_pr__cap_mim_m3_1_L4DLLG_2 m1_2444_n34551# m1_764_n34560# sky130_fd_pr__cap_mim_m3_1_L4DLLG
Xsky130_fd_pr__cap_mim_m3_1_L4DLLG_3 m1_2444_n48551# m1_764_n48560# sky130_fd_pr__cap_mim_m3_1_L4DLLG
Xsky130_fd_pr__pfet_01v8_lvt_C38N8W_5 m1_636_n48560# m1_764_n34560# VPWR sky130_fd_sc_hs__inv_16_4/A
+ m1_636_n48560# m1_764_n34560# m1_764_n34560# m1_636_n48560# m1_636_n48560# m1_764_n34560#
+ m1_636_n48560# m1_636_n48560# m1_764_n34560# sky130_fd_pr__pfet_01v8_lvt_C38N8W
Xsky130_fd_pr__pfet_01v8_lvt_C38N8W_6 VPWR m1_764_n48560# VPWR sky130_fd_sc_hs__inv_16_6/Y
+ VPWR m1_764_n48560# m1_764_n48560# VPWR VPWR m1_764_n48560# VPWR VPWR m1_764_n48560#
+ sky130_fd_pr__pfet_01v8_lvt_C38N8W
Xsky130_fd_pr__pfet_01v8_lvt_C38N8W_7 m1_636_n48560# m1_764_n48560# VPWR sky130_fd_sc_hs__inv_16_6/A
+ m1_636_n48560# m1_764_n48560# m1_764_n48560# m1_636_n48560# m1_636_n48560# m1_764_n48560#
+ m1_636_n48560# m1_636_n48560# m1_764_n48560# sky130_fd_pr__pfet_01v8_lvt_C38N8W
Xsky130_fd_pr__nfet_01v8_lvt_9G3FLA_0 m1_2444_n6551# sky130_fd_sc_hs__inv_16_0/A sky130_fd_sc_hs__inv_16_0/A
+ sky130_fd_sc_hs__inv_16_0/A GND GND m1_2444_n6551# m1_2444_n6551# sky130_fd_sc_hs__inv_16_0/A
+ GND sky130_fd_sc_hs__inv_16_0/A GND sky130_fd_sc_hs__inv_16_0/A m1_2444_n6551# GND
+ sky130_fd_sc_hs__inv_16_0/A m1_2444_n6551# GND sky130_fd_sc_hs__inv_16_0/A sky130_fd_sc_hs__inv_16_0/A
+ GND sky130_fd_sc_hs__inv_16_0/A sky130_fd_pr__nfet_01v8_lvt_9G3FLA
Xsky130_fd_pr__nfet_01v8_lvt_9G3FLA_1 m1_2444_n20551# sky130_fd_sc_hs__inv_16_1/A
+ sky130_fd_sc_hs__inv_16_1/A sky130_fd_sc_hs__inv_16_1/A GND GND m1_2444_n20551#
+ m1_2444_n20551# sky130_fd_sc_hs__inv_16_1/A GND sky130_fd_sc_hs__inv_16_1/A GND
+ sky130_fd_sc_hs__inv_16_1/A m1_2444_n20551# GND sky130_fd_sc_hs__inv_16_1/A m1_2444_n20551#
+ GND sky130_fd_sc_hs__inv_16_1/A sky130_fd_sc_hs__inv_16_1/A GND sky130_fd_sc_hs__inv_16_1/A
+ sky130_fd_pr__nfet_01v8_lvt_9G3FLA
Xsky130_fd_pr__nfet_01v8_lvt_9G3FLA_2 m1_2444_n34551# sky130_fd_sc_hs__inv_16_4/A
+ sky130_fd_sc_hs__inv_16_4/A sky130_fd_sc_hs__inv_16_4/A GND GND m1_2444_n34551#
+ m1_2444_n34551# sky130_fd_sc_hs__inv_16_4/A GND sky130_fd_sc_hs__inv_16_4/A GND
+ sky130_fd_sc_hs__inv_16_4/A m1_2444_n34551# GND sky130_fd_sc_hs__inv_16_4/A m1_2444_n34551#
+ GND sky130_fd_sc_hs__inv_16_4/A sky130_fd_sc_hs__inv_16_4/A GND sky130_fd_sc_hs__inv_16_4/A
+ sky130_fd_pr__nfet_01v8_lvt_9G3FLA
.ends

.subckt sky130_fd_pr__nfet_01v8_DPBXBZ a_337_n588# a_587_n500# a_n337_n500# a_n587_n588#
+ a_279_n500# a_29_n588# a_n747_n674# a_n29_n500# a_n645_n500# a_n279_n588#
X0 a_n29_n500# a_n279_n588# a_n337_n500# a_n747_n674# sky130_fd_pr__nfet_01v8 ad=1.45e+12p pd=1.058e+07u as=1.45e+12p ps=1.058e+07u w=5e+06u l=1.25e+06u
X1 a_587_n500# a_337_n588# a_279_n500# a_n747_n674# sky130_fd_pr__nfet_01v8 ad=1.45e+12p pd=1.058e+07u as=1.45e+12p ps=1.058e+07u w=5e+06u l=1.25e+06u
X2 a_n337_n500# a_n587_n588# a_n645_n500# a_n747_n674# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=1.45e+12p ps=1.058e+07u w=5e+06u l=1.25e+06u
X3 a_279_n500# a_29_n588# a_n29_n500# a_n747_n674# sky130_fd_pr__nfet_01v8 ad=0p pd=0u as=0p ps=0u w=5e+06u l=1.25e+06u
.ends

.subckt sky130_fd_pr__rf_npn_05v5_W1p00L2p00 w_360_360# a_762_762# dw_80_80# VSUBS
+ m=1
X0 dw_80_80# w_360_360# a_762_762# VSUBS sky130_fd_pr__npn_05v5_W1p00L2p00
.ends

.subckt sky130_fd_pr__diode_pd2nw_11v0_VFE9GT a_n2594_n1198# a_n16554_n1198# a_16950_198#
+ a_12762_198# a_198_198# a_14158_n1198# a_n1198_198# a_n5386_198# a_n9574_198# a_n8178_n1198#
+ a_15554_n1198# a_n3990_n1198# a_n17950_n1198# a_1594_n1198# a_n9574_n1198# a_n10970_198#
+ a_7178_n1198# a_5782_198# a_1594_198# a_9970_198# a_n15158_198# a_16950_n1198# a_n2594_198#
+ a_n19346_198# a_2990_n1198# a_n12366_n1198# a_n20742_n1198# a_n6782_198# a_n20742_198#
+ a_8574_n1198# a_18346_198# a_14158_198# a_198_n1198# a_n13762_n1198# a_11366_n1198#
+ a_9970_n1198# a_n5386_n1198# a_n19346_n1198# a_2990_198# a_n12366_198# a_n16554_198#
+ a_n3990_198# a_12762_n1198# a_7178_198# a_18346_n1198# a_n6782_n1198# a_15554_198#
+ a_11366_198# w_n20940_n1396# a_4386_n1198# a_19742_198# a_n8178_198# a_19742_n1198#
+ a_n15158_n1198# a_5782_n1198# a_n1198_n1198# a_n13762_198# a_n17950_198# a_4386_198#
+ a_n10970_n1198# a_8574_198#
D0 a_15554_198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D1 a_8574_n1198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D2 a_n1198_198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D3 a_n19346_198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D4 a_9970_198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D5 a_n13762_198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D6 a_n2594_n1198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D7 a_19742_n1198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D8 a_14158_198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D9 a_n20742_n1198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D10 a_n16554_n1198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D11 a_n3990_n1198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D12 a_7178_n1198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D13 a_n6782_198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D14 a_198_198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D15 a_8574_198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D16 a_n17950_n1198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D17 a_5782_n1198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D18 a_n20742_198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D19 a_n12366_198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D20 a_2990_198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D21 a_n1198_n1198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D22 a_18346_n1198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D23 a_16950_n1198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D24 a_19742_198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D25 a_n15158_n1198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D26 a_n5386_198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D27 a_7178_198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D28 a_1594_198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D29 a_n13762_n1198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D30 a_n9574_n1198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D31 a_4386_n1198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D32 a_n17950_198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D33 a_18346_198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D34 a_2990_n1198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D35 a_12762_198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D36 a_15554_n1198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D37 a_n16554_198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D38 a_n12366_n1198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D39 a_n8178_n1198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D40 a_n10970_198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D41 a_n6782_n1198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D42 a_1594_n1198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D43 a_n9574_198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D44 a_11366_198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D45 a_n15158_198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D46 a_14158_n1198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D47 a_5782_198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D48 a_12762_n1198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D49 a_n3990_198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D50 a_9970_n1198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D51 a_n8178_198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D52 a_16950_198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D53 a_n5386_n1198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D54 a_4386_198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D55 a_n2594_198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D56 a_n10970_n1198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D57 a_n19346_n1198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D58 a_198_n1198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D59 a_11366_n1198# w_n20940_n1396# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
.ends

.subckt sky130_fd_pr__diode_pd2nw_11v0_6YHF4V a_n2594_n1198# a_198_198# a_1594_n2594#
+ a_n1198_198# a_1594_n1198# a_198_1594# a_1594_198# a_198_n2594# a_n2594_198# a_n1198_1594#
+ a_198_n1198# a_n2594_1594# w_n2792_n2792# a_1594_1594# a_n1198_n2594# a_n2594_n2594#
+ a_n1198_n1198#
D0 a_n1198_198# w_n2792_n2792# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D1 a_1594_n2594# w_n2792_n2792# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D2 a_n2594_n1198# w_n2792_n2792# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D3 a_1594_1594# w_n2792_n2792# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D4 a_198_198# w_n2792_n2792# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D5 a_n2594_1594# w_n2792_n2792# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D6 a_n1198_n1198# w_n2792_n2792# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D7 a_n1198_1594# w_n2792_n2792# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D8 a_198_n2594# w_n2792_n2792# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D9 a_1594_198# w_n2792_n2792# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D10 a_n2594_n2594# w_n2792_n2792# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D11 a_198_1594# w_n2792_n2792# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D12 a_1594_n1198# w_n2792_n2792# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D13 a_n1198_n2594# w_n2792_n2792# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D14 a_n2594_198# w_n2792_n2792# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D15 a_198_n1198# w_n2792_n2792# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
.ends

.subckt sky130_fd_pr__nfet_g5v0d10v5_KBPKF4 a_n3979_n2220# a_2025_n400# a_n1293_n2220#
+ a_n445_n2308# a_2499_n1310# a_n661_1420# a_4237_n400# a_3347_n2308# a_n3763_n2308#
+ a_287_1420# a_n1925_1420# a_n919_n2308# a_n1767_n2220# a_n2241_1420# a_4553_n2220#
+ a_1135_n2308# a_n6483_n2442# a_n4453_1420# a_n1551_n2308# a_n661_n2220# a_1235_n400#
+ a_3447_n400# a_1609_n2308# a_5659_n400# a_2341_n2220# a_n4611_n1310# a_2815_n2220#
+ a_n1451_1420# a_2973_n1310# a_n3663_1420# a_3821_n2308# a_761_n400# a_n5875_1420#
+ a_345_n2308# a_3763_510# a_n3663_510# a_2815_510# a_n287_n2308# a_1077_510# a_n2715_510#
+ a_n977_510# a_2657_n400# a_n6191_1420# a_4869_n400# a_3189_n2308# a_819_n2308# a_n6191_n1310#
+ a_n6033_n2220# a_5185_n400# a_4395_n2220# a_n2873_1420# a_n1393_n2308# a_5027_n1310#
+ a_5501_510# a_n5401_510# a_1867_n400# a_4869_n2220# a_n1867_n2308# a_2183_n2220#
+ a_n4453_n1310# a_n977_n2220# a_5875_n2308# a_2183_n400# a_4395_n400# a_919_1420#
+ a_2657_n2220# a_n761_n2308# a_129_510# a_n4927_n1310# a_3663_n2308# a_n2241_n1310#
+ a_187_n2308# a_n29_n400# a_n2715_n1310# a_n5401_1420# a_1451_n2308# a_1393_n400#
+ a_n6349_510# a_5501_n1310# a_1925_n2308# a_n6349_n2220# a_445_1420# a_n6133_n2308#
+ a_n4611_1420# a_n4295_n1310# a_n4137_n2220# a_2657_510# a_661_n2308# a_n2557_510#
+ a_1709_510# a_3605_n400# a_2499_n2220# a_n1609_510# a_5817_n400# a_n4769_n1310#
+ a_n2083_n1310# a_6133_n400# a_n187_n400# a_6291_510# a_n2557_n1310# a_n3821_1420#
+ a_3979_n2308# a_1293_n2308# a_n6191_510# a_5343_510# a_4079_1420# a_n5243_510# a_5343_n1310#
+ a_2815_n400# a_1767_n2308# a_3131_n400# a_n4611_n2220# a_5817_n1310# a_5343_n400#
+ a_3131_n1310# a_n29_510# a_2973_n2220# a_1077_1420# a_129_n1310# a_3605_n1310# a_3289_1420#
+ a_1551_510# a_n1451_510# a_n3189_n400# a_977_n2308# a_2341_n400# a_4553_n400# a_n6191_n2220#
+ a_n4237_n2308# a_n2399_n1310# a_2499_1420# a_5027_n2220# a_5185_n1310# a_n2025_n2308#
+ a_6033_n2308# a_n2399_n400# a_2499_510# a_n503_510# a_1551_n400# a_n2399_510# a_n4453_n2220#
+ a_5659_n1310# a_3763_n400# a_5975_n400# a_603_n1310# a_603_510# a_6291_n400# a_n4927_n2220#
+ a_603_1420# a_n819_n400# a_n2241_n2220# a_3447_n1310# a_n4711_n2308# a_5185_510#
+ a_n2873_n1310# a_n2715_n2220# a_n5085_510# a_1235_n1310# a_4237_510# a_2973_n400#
+ a_5027_1420# a_n4079_n2308# a_n4137_510# a_5501_n2220# a_1709_n1310# a_1709_1420#
+ a_n345_n400# a_n6291_n2308# a_2025_1420# a_1393_510# a_n1609_n400# a_n4295_n2220#
+ a_4237_1420# a_n1293_510# a_445_n1310# a_3921_n1310# a_n4137_n400# a_n4769_n2220#
+ a_n6349_n400# a_n2083_n2220# a_3289_n1310# a_5501_n400# a_919_n1310# a_4137_n2308#
+ a_n4553_n2308# a_n2557_n2220# a_1235_1420# a_1077_n1310# a_3447_1420# a_3131_510#
+ a_5659_1420# a_5343_n2220# a_n3031_510# a_n2341_n2308# a_n1135_n400# a_n345_510#
+ a_n3979_510# a_n3347_n400# a_n5559_n400# a_4711_n400# a_5817_n2220# a_5975_n1310#
+ a_n2815_n2308# a_3131_n2220# a_445_510# a_761_1420# a_n5401_n1310# a_n977_n400#
+ a_2657_1420# a_3605_n2220# a_4869_1420# a_287_n1310# a_3763_n1310# a_129_n2220#
+ a_4611_n2308# a_5817_510# a_n2557_n400# a_5185_1420# a_4079_510# a_n5717_510# a_n4769_n400#
+ a_3921_n400# a_1551_n1310# a_n4395_n2308# a_n5085_n400# a_n2399_n2220# a_1867_1420#
+ a_5185_n2220# a_n4869_n2308# a_n2183_n2308# a_2183_1420# a_2973_510# a_6191_n2308#
+ a_4395_1420# a_n1767_n400# a_n2873_510# a_n3979_n400# a_n1925_510# a_5659_n2220#
+ a_n2657_n2308# a_n2083_n400# a_n4295_n400# a_761_n1310# a_603_n2220# a_n5243_n1310#
+ a_n29_1420# a_n29_n1310# a_3447_n2220# a_n503_n400# a_n5717_n1310# a_4453_n2308#
+ a_1393_1420# a_n3031_n1310# a_4711_510# a_129_n400# a_n2873_n2220# a_n4611_510#
+ a_1393_n1310# a_1235_n2220# a_2025_510# a_n1293_n400# a_n3505_n1310# a_4927_n2308#
+ a_n187_510# a_2241_n2308# a_1709_n2220# a_1867_n1310# a_287_510# a_2715_n2308# a_3605_1420#
+ a_n2499_n2308# a_5817_1420# a_3921_n2220# a_445_n2220# a_5659_510# a_n5085_n1310#
+ a_6133_1420# a_n5559_510# a_n3505_n400# a_n5717_n400# a_n187_1420# a_3289_n2220#
+ a_919_n2220# a_n6033_n400# a_n5559_n1310# a_4295_n2308# a_2815_1420# a_1077_n2220#
+ a_n3347_n1310# a_4769_n2308# a_2083_n2308# a_3131_1420# a_1867_510# a_n2715_n400#
+ a_5343_1420# a_n1767_510# a_n4927_n400# a_6133_n1310# a_n3031_n400# a_2557_n2308#
+ a_n5243_n400# a_n1135_n1310# a_5975_n2220# a_n2973_n2308# a_n5401_n2220# a_n661_n400#
+ a_n1609_n1310# a_3763_n2220# a_287_n2220# a_n3189_1420# a_2341_1420# a_4553_510#
+ a_287_n400# a_4553_1420# a_n1925_n400# a_n4453_510# a_3605_510# a_n503_n1310# a_n3505_510#
+ a_n2241_n400# a_1551_n2220# a_n819_510# a_n4453_n400# a_n3821_n1310# a_29_n2308#
+ a_n5027_n2308# a_919_510# a_n3189_n1310# a_n2399_1420# a_1551_1420# a_3763_1420#
+ a_5975_1420# a_n1451_n400# a_2399_n2308# a_n3663_n400# a_6291_1420# a_n819_1420#
+ a_n5875_n400# a_761_n2220# a_n5243_n2220# a_n29_n2220# a_n6191_n400# a_n5875_n1310#
+ a_n3031_n2220# a_n5717_n2220# a_2973_1420# a_4237_n1310# a_n345_n1310# a_n5501_n2308#
+ a_n661_510# a_1393_n2220# a_n2873_n400# a_n3663_n1310# a_n3505_n2220# a_2025_n1310#
+ a_n819_n1310# a_761_510# a_n345_1420# a_1867_n2220# a_2873_n2308# a_n1451_n1310#
+ a_n1609_1420# a_919_n400# a_n1925_n1310# a_4395_510# a_n4137_1420# a_n6349_1420#
+ a_n4295_510# a_3447_510# a_n5085_n2220# a_5501_1420# a_n3347_510# a_4711_n1310#
+ a_n5401_n400# a_n5559_n2220# a_4079_n1310# a_n187_n1310# a_n5343_n2308# a_n1135_1420#
+ a_n3347_1420# a_n3347_n2220# a_n5559_1420# a_6133_510# a_445_n400# a_4711_1420#
+ a_n6033_510# a_6133_n2220# a_n5817_n2308# a_6291_n1310# a_n3131_n2308# a_n977_1420#
+ a_n4611_n400# a_n3979_n1310# a_n1135_n2220# a_n1293_n1310# a_n3605_n2308# a_n2557_1420#
+ a_n1767_n1310# a_n1609_n2220# a_n4769_1420# a_3921_1420# a_2341_510# a_4553_n1310#
+ a_n2241_510# a_n661_n1310# a_n503_n2220# a_n5085_1420# a_5401_n2308# a_n3821_n400#
+ a_n3821_n2220# a_4079_n400# a_2341_n1310# a_n5185_n2308# a_n1767_1420# a_n3189_n2220#
+ a_n3979_1420# a_2815_n1310# a_n2083_1420# a_n5659_n2308# a_5975_510# a_n4295_1420#
+ a_n5875_510# a_n129_n2308# a_3289_510# a_n4927_510# a_1077_n400# a_n3189_510# a_3289_n400#
+ a_n3447_n2308# a_n503_1420# a_n6033_n1310# a_129_1420# a_n5875_n2220# a_4237_n2220#
+ a_n1293_1420# a_4395_n1310# a_n1235_n2308# a_n345_n2220# a_5243_n2308# a_5027_510#
+ a_n3663_n2220# a_4869_n1310# a_2499_n400# a_2183_n1310# a_2025_n2220# a_n1709_n2308#
+ a_n977_n1310# a_n819_n2220# a_5717_n2308# a_3031_n2308# a_n1451_n2220# a_n603_n2308#
+ a_2657_n1310# a_3505_n2308# a_n3921_n2308# a_n3505_1420# a_3921_510# a_603_n400#
+ a_n1925_n2220# a_n5717_1420# a_2183_510# a_n3821_510# a_n2083_510# a_n3289_n2308#
+ a_1235_510# a_4711_n2220# a_n6033_1420# a_n1135_510# a_5027_n400# a_4079_n2220#
+ a_n1077_n2308# a_n6349_n1310# a_n187_n2220# a_5085_n2308# a_n2715_1420# a_n4927_1420#
+ a_n3031_1420# a_n4137_n1310# a_n5243_1420# a_5559_n2308# a_4869_510# a_1709_n400#
+ a_6291_n2220# a_n5975_n2308# a_503_n2308# a_n4769_510#
X0 a_2183_1420# a_2083_n2308# a_2025_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X1 a_n5401_n2220# a_n5501_n2308# a_n5559_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X2 a_n2557_n1310# a_n2657_n2308# a_n2715_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X3 a_3447_n2220# a_3347_n2308# a_3289_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X4 a_3605_510# a_3505_n2308# a_3447_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X5 a_n2083_1420# a_n2183_n2308# a_n2241_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X6 a_n503_n400# a_n603_n2308# a_n661_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X7 a_n6033_n2220# a_n6133_n2308# a_n6191_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X8 a_n3189_n1310# a_n3289_n2308# a_n3347_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X9 a_3131_510# a_3031_n2308# a_2973_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X10 a_5501_n400# a_5401_n2308# a_5343_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X11 a_2657_n400# a_2557_n2308# a_2499_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X12 a_5817_510# a_5717_n2308# a_5659_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X13 a_n819_n2220# a_n919_n2308# a_n977_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X14 a_2815_n1310# a_2715_n2308# a_2657_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X15 a_n2557_n400# a_n2657_n2308# a_n2715_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X16 a_n5401_n400# a_n5501_n2308# a_n5559_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X17 a_n5401_n1310# a_n5501_n2308# a_n5559_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X18 a_5343_510# a_5243_n2308# a_5185_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X19 a_2973_n2220# a_2873_n2308# a_2815_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X20 a_3447_n1310# a_3347_n2308# a_3289_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X21 a_603_510# a_503_n2308# a_445_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X22 a_n6033_n1310# a_n6133_n2308# a_n6191_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X23 a_4237_1420# a_4137_n2308# a_4079_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X24 a_n977_n2220# a_n1077_n2308# a_n1135_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X25 a_3763_1420# a_3663_n2308# a_3605_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X26 a_n4137_1420# a_n4237_n2308# a_n4295_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X27 a_n3663_1420# a_n3763_n2308# a_n3821_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X28 a_n819_n1310# a_n919_n2308# a_n977_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X29 a_n6191_n2220# a_n6291_n2308# a_n6349_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X30 a_1235_n2220# a_1135_n2308# a_1077_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X31 a_2973_n1310# a_2873_n2308# a_2815_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X32 a_n6033_510# a_n6133_n2308# a_n6191_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X33 a_n977_n1310# a_n1077_n2308# a_n1135_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X34 a_n819_1420# a_n919_n2308# a_n977_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X35 a_603_n400# a_503_n2308# a_445_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X36 a_n29_n400# a_n129_n2308# a_n187_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X37 a_5817_1420# a_5717_n2308# a_5659_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X38 a_n6191_n1310# a_n6291_n2308# a_n6349_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X39 a_n5717_1420# a_n5817_n2308# a_n5875_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X40 a_4553_n400# a_4453_n2308# a_4395_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X41 a_5501_510# a_5401_n2308# a_5343_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X42 a_n4927_n400# a_n5027_n2308# a_n5085_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X43 a_1235_n1310# a_1135_n2308# a_1077_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X44 a_n4453_n400# a_n4553_n2308# a_n4611_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X45 a_n661_1420# a_n761_n2308# a_n819_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X46 a_1393_n2220# a_1293_n2308# a_1235_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X47 a_4079_n2220# a_3979_n2308# a_3921_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X48 a_3289_1420# a_3189_n2308# a_3131_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X49 a_6133_1420# a_6033_n2308# a_5975_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X50 a_603_n2220# a_503_n2308# a_445_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X51 a_n3189_1420# a_n3289_n2308# a_n3347_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X52 a_n6033_1420# a_n6133_n2308# a_n6191_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X53 a_n1767_510# a_n1867_n2308# a_n1925_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X54 a_1709_n2220# a_1609_n2308# a_1551_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X55 a_1393_n1310# a_1293_n2308# a_1235_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X56 a_n1293_510# a_n1393_n2308# a_n1451_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X57 a_919_1420# a_819_n2308# a_761_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X58 a_4079_n1310# a_3979_n2308# a_3921_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X59 a_603_n1310# a_503_n2308# a_445_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X60 a_n4927_n2220# a_n5027_n2308# a_n5085_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X61 a_4869_1420# a_4769_n2308# a_4711_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X62 a_761_n2220# a_661_n2308# a_603_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X63 a_1709_n1310# a_1609_n2308# a_1551_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X64 a_n4769_1420# a_n4869_n2308# a_n4927_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X65 a_2025_1420# a_1925_n2308# a_1867_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X66 a_n3979_n400# a_n4079_n2308# a_n4137_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X67 a_1235_n400# a_1135_n2308# a_1077_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X68 a_n1135_n400# a_n1235_n2308# a_n1293_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X69 a_n3821_n2220# a_n3921_n2308# a_n3979_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X70 a_1867_n2220# a_1767_n2308# a_1709_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X71 a_2973_510# a_2873_n2308# a_2815_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X72 a_761_1420# a_661_n2308# a_603_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X73 a_n187_1420# a_n287_n2308# a_n345_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X74 a_n4927_n1310# a_n5027_n2308# a_n5085_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X75 a_n4453_n2220# a_n4553_n2308# a_n4611_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X76 a_2499_n2220# a_2399_n2308# a_2341_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X77 a_5185_1420# a_5085_n2308# a_5027_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X78 a_761_n1310# a_661_n2308# a_603_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X79 a_n5085_1420# a_n5185_n2308# a_n5243_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X80 a_2341_1420# a_2241_n2308# a_2183_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X81 a_n5085_n2220# a_n5185_n2308# a_n5243_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X82 a_n1451_510# a_n1551_n2308# a_n1609_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X83 a_n2241_1420# a_n2341_n2308# a_n2399_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X84 a_n3821_n1310# a_n3921_n2308# a_n3979_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X85 a_4711_n2220# a_4611_n2308# a_4553_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X86 a_1867_n1310# a_1767_n2308# a_1709_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X87 a_5659_n400# a_5559_n2308# a_5501_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X88 a_n5559_n400# a_n5659_n2308# a_n5717_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X89 a_2815_n400# a_2715_n2308# a_2657_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X90 a_n3663_510# a_n3763_n2308# a_n3821_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X91 a_n4453_n1310# a_n4553_n2308# a_n4611_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X92 a_n2715_n400# a_n2815_n2308# a_n2873_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X93 a_5343_n2220# a_5243_n2308# a_5185_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X94 a_2499_n1310# a_2399_n2308# a_2341_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X95 a_2499_510# a_2399_n2308# a_2341_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X96 a_n5085_n1310# a_n5185_n2308# a_n5243_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X97 a_n5875_510# a_n5975_n2308# a_n6033_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X98 a_4711_n1310# a_4611_n2308# a_4553_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X99 a_3921_1420# a_3821_n2308# a_3763_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X100 a_n3821_1420# a_n3921_n2308# a_n3979_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X101 a_3131_n400# a_3031_n2308# a_2973_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X102 a_n2241_n2220# a_n2341_n2308# a_n2399_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X103 a_n977_510# a_n1077_n2308# a_n1135_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X104 a_5343_n1310# a_5243_n2308# a_5185_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X105 a_n3031_n400# a_n3131_n2308# a_n3189_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X106 a_287_1420# a_187_n2308# a_129_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X107 a_n3189_510# a_n3289_n2308# a_n3347_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X108 a_n5559_n2220# a_n5659_n2308# a_n5717_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X109 a_1393_1420# a_1293_n2308# a_1235_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X110 a_n3821_510# a_n3921_n2308# a_n3979_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X111 a_n1293_1420# a_n1393_n2308# a_n1451_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X112 a_n2241_n1310# a_n2341_n2308# a_n2399_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X113 a_3131_n2220# a_3031_n2308# a_2973_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X114 a_5817_n2220# a_5717_n2308# a_5659_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X115 a_1867_n400# a_1767_n2308# a_1709_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X116 a_2657_510# a_2557_n2308# a_2499_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X117 a_4711_n400# a_4611_n2308# a_4553_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X118 a_n1767_n400# a_n1867_n2308# a_n1925_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X119 a_n4611_n400# a_n4711_n2308# a_n4769_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X120 a_n503_n2220# a_n603_n2308# a_n661_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X121 a_n1609_510# a_n1709_n2308# a_n1767_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X122 a_n5559_n1310# a_n5659_n2308# a_n5717_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X123 a_4869_510# a_4769_n2308# a_4711_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X124 a_2183_510# a_2083_n2308# a_2025_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X125 a_n1135_510# a_n1235_n2308# a_n1293_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X126 a_3131_n1310# a_3031_n2308# a_2973_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X127 a_3447_1420# a_3347_n2308# a_3289_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X128 a_n2715_n2220# a_n2815_n2308# a_n2873_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X129 a_4395_510# a_4295_n2308# a_4237_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X130 a_2973_1420# a_2873_n2308# a_2815_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X131 a_287_n2220# a_187_n2308# a_129_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X132 a_n3347_1420# a_n3447_n2308# a_n3505_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X133 a_5817_n1310# a_5717_n2308# a_5659_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X134 a_2183_n400# a_2083_n2308# a_2025_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X135 a_n2873_1420# a_n2973_n2308# a_n3031_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X136 a_n2083_n400# a_n2183_n2308# a_n2241_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X137 a_n3347_510# a_n3447_n2308# a_n3505_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X138 a_n503_n1310# a_n603_n2308# a_n661_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X139 a_n3347_n2220# a_n3447_n2308# a_n3505_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X140 a_5975_n2220# a_5875_n2308# a_5817_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X141 a_n5559_510# a_n5659_n2308# a_n5717_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X142 a_n661_n2220# a_n761_n2308# a_n819_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X143 a_n3979_n2220# a_n4079_n2308# a_n4137_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X144 a_n2715_n1310# a_n2815_n2308# a_n2873_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X145 a_3605_n2220# a_3505_n2308# a_3447_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X146 a_287_n1310# a_187_n2308# a_129_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X147 a_2815_510# a_2715_n2308# a_2657_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X148 a_n5085_510# a_n5185_n2308# a_n5243_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X149 a_n3347_n1310# a_n3447_n2308# a_n3505_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X150 a_5027_1420# a_4927_n2308# a_4869_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X151 a_n2873_n2220# a_n2973_n2308# a_n3031_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X152 a_4237_n2220# a_4137_n2308# a_4079_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X153 a_2341_510# a_2241_n2308# a_2183_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X154 a_5975_n1310# a_5875_n2308# a_5817_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X155 a_4237_n400# a_4137_n2308# a_4079_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X156 a_3763_n400# a_3663_n2308# a_3605_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X157 a_5027_510# a_4927_n2308# a_4869_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X158 a_n3663_n400# a_n3763_n2308# a_n3821_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X159 a_n4137_n400# a_n4237_n2308# a_n4295_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X160 a_n661_n1310# a_n761_n2308# a_n819_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X161 a_n3979_n1310# a_n4079_n2308# a_n4137_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X162 a_4553_510# a_4453_n2308# a_4395_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X163 a_n345_1420# a_n445_n2308# a_n503_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X164 a_3605_n1310# a_3505_n2308# a_3447_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X165 a_n3505_510# a_n3605_n2308# a_n3663_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X166 a_n661_510# a_n761_n2308# a_n819_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X167 a_2499_1420# a_2399_n2308# a_2341_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X168 a_n1135_n2220# a_n1235_n2308# a_n1293_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X169 a_n2873_n1310# a_n2973_n2308# a_n3031_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X170 a_5343_1420# a_5243_n2308# a_5185_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X171 a_4237_n1310# a_4137_n2308# a_4079_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X172 a_n2399_1420# a_n2499_n2308# a_n2557_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X173 a_n5243_1420# a_n5343_n2308# a_n5401_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X174 a_3763_n2220# a_3663_n2308# a_3605_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X175 a_n819_n400# a_n919_n2308# a_n977_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X176 a_n3031_510# a_n3131_n2308# a_n3189_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X177 a_n5717_510# a_n5817_n2308# a_n5875_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X178 a_6291_510# a_6191_n2308# a_6133_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X179 a_129_510# a_29_n2308# a_n29_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X180 a_4395_n2220# a_4295_n2308# a_4237_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X181 a_5817_n400# a_5717_n2308# a_5659_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X182 a_n5717_n400# a_n5817_n2308# a_n5875_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X183 a_n5243_510# a_n5343_n2308# a_n5401_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X184 a_n1135_n1310# a_n1235_n2308# a_n1293_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X185 a_129_1420# a_29_n2308# a_n29_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X186 a_3763_n1310# a_3663_n2308# a_3605_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X187 a_n661_n400# a_n761_n2308# a_n819_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X188 a_4079_1420# a_3979_n2308# a_3921_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X189 a_n1293_n2220# a_n1393_n2308# a_n1451_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X190 a_4395_n1310# a_4295_n2308# a_4237_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X191 a_3289_n400# a_3189_n2308# a_3131_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X192 a_n187_510# a_n287_n2308# a_n345_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X193 a_6133_n400# a_6033_n2308# a_5975_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X194 a_4711_510# a_4611_n2308# a_4553_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X195 a_1709_1420# a_1609_n2308# a_1551_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X196 a_n3189_n400# a_n3289_n2308# a_n3347_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X197 a_n6033_n400# a_n6133_n2308# a_n6191_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X198 a_n1609_1420# a_n1709_n2308# a_n1767_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X199 a_445_1420# a_345_n2308# a_287_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X200 a_n29_n2220# a_n129_n2308# a_n187_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X201 a_1551_n2220# a_1451_n2308# a_1393_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X202 a_n1609_n2220# a_n1709_n2308# a_n1767_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X203 a_n1293_n1310# a_n1393_n2308# a_n1451_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X204 a_4395_1420# a_4295_n2308# a_4237_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X205 a_919_n400# a_819_n2308# a_761_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X206 a_n4295_1420# a_n4395_n2308# a_n4453_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X207 a_2183_n2220# a_2083_n2308# a_2025_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X208 a_1551_1420# a_1451_n2308# a_1393_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X209 a_n1925_1420# a_n2025_n2308# a_n2083_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X210 a_4869_n2220# a_4769_n2308# a_4711_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X211 a_n5401_510# a_n5501_n2308# a_n5559_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X212 a_n1451_1420# a_n1551_n2308# a_n1609_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X213 a_n29_n1310# a_n129_n2308# a_n187_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X214 a_4869_n400# a_4769_n2308# a_4711_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X215 a_1551_n1310# a_1451_n2308# a_1393_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X216 a_n4769_n400# a_n4869_n2308# a_n4927_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X217 a_n819_510# a_n919_n2308# a_n977_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X218 a_2025_n400# a_1925_n2308# a_1867_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X219 a_4237_510# a_4137_n2308# a_4079_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X220 a_n1609_n1310# a_n1709_n2308# a_n1767_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X221 a_n187_n2220# a_n287_n2308# a_n345_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X222 a_2183_n1310# a_2083_n2308# a_2025_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X223 a_n345_510# a_n445_n2308# a_n503_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X224 a_761_n400# a_661_n2308# a_603_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X225 a_n187_n400# a_n287_n2308# a_n345_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X226 a_n1767_n2220# a_n1867_n2308# a_n1925_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X227 a_4869_n1310# a_4769_n2308# a_4711_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X228 a_5975_1420# a_5875_n2308# a_5817_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X229 a_5185_n400# a_5085_n2308# a_5027_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X230 a_n5875_1420# a_n5975_n2308# a_n6033_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X231 a_3605_1420# a_3505_n2308# a_3447_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X232 a_n5085_n400# a_n5185_n2308# a_n5243_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X233 a_n2399_n2220# a_n2499_n2308# a_n2557_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X234 a_n3505_1420# a_n3605_n2308# a_n3663_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X235 a_2341_n400# a_2241_n2308# a_2183_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X236 a_n2241_n400# a_n2341_n2308# a_n2399_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X237 a_2025_n2220# a_1925_n2308# a_1867_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X238 a_n4927_510# a_n5027_n2308# a_n5085_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X239 a_n187_n1310# a_n287_n2308# a_n345_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X240 a_n4611_n2220# a_n4711_n2308# a_n4769_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X241 a_n1767_n1310# a_n1867_n2308# a_n1925_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X242 a_2657_n2220# a_2557_n2308# a_2499_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X243 a_6291_1420# a_6191_n2308# a_6133_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X244 a_n6191_1420# a_n6291_n2308# a_n6349_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X245 a_n5243_n2220# a_n5343_n2308# a_n5401_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X246 a_n2399_n1310# a_n2499_n2308# a_n2557_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X247 a_3289_n2220# a_3189_n2308# a_3131_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X248 a_n977_1420# a_n1077_n2308# a_n1135_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X249 a_2025_n1310# a_1925_n2308# a_1867_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X250 a_n503_510# a_n603_n2308# a_n661_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X251 a_3921_n400# a_3821_n2308# a_3763_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X252 a_n2873_510# a_n2973_n2308# a_n3031_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X253 a_n4611_n1310# a_n4711_n2308# a_n4769_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X254 a_n3821_n400# a_n3921_n2308# a_n3979_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X255 a_5501_n2220# a_5401_n2308# a_5343_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X256 a_2657_n1310# a_2557_n2308# a_2499_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X257 a_1077_1420# a_977_n2308# a_919_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X258 a_287_n400# a_187_n2308# a_129_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X259 a_n5243_n1310# a_n5343_n2308# a_n5401_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X260 a_6133_510# a_6033_n2308# a_5975_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X261 a_n503_1420# a_n603_n2308# a_n661_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X262 a_6133_n2220# a_6033_n2308# a_5975_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X263 a_3289_n1310# a_3189_n2308# a_3131_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X264 a_2657_1420# a_2557_n2308# a_2499_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X265 a_5501_1420# a_5401_n2308# a_5343_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X266 a_n2557_1420# a_n2657_n2308# a_n2715_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X267 a_n5401_1420# a_n5501_n2308# a_n5559_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X268 a_1393_n400# a_1293_n2308# a_1235_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X269 a_5501_n1310# a_5401_n2308# a_5343_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X270 a_n1293_n400# a_n1393_n2308# a_n1451_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X271 a_129_n2220# a_29_n2308# a_n29_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X272 a_n3031_n2220# a_n3131_n2308# a_n3189_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X273 a_n29_510# a_n129_n2308# a_n187_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X274 a_6133_n1310# a_6033_n2308# a_5975_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X275 a_n2399_510# a_n2499_n2308# a_n2557_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X276 a_n5717_n2220# a_n5817_n2308# a_n5875_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X277 a_6291_n2220# a_6191_n2308# a_6133_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X278 a_129_n1310# a_29_n2308# a_n29_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X279 a_3447_n400# a_3347_n2308# a_3289_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X280 a_1867_510# a_1767_n2308# a_1709_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X281 a_n3031_n1310# a_n3131_n2308# a_n3189_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X282 a_2973_n400# a_2873_n2308# a_2815_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X283 a_n3347_n400# a_n3447_n2308# a_n3505_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X284 a_n2873_n400# a_n2973_n2308# a_n3031_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X285 a_n5717_n1310# a_n5817_n2308# a_n5875_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X286 a_603_1420# a_503_n2308# a_445_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X287 a_4079_510# a_3979_n2308# a_3921_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X288 a_1393_510# a_1293_n2308# a_1235_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X289 a_n29_1420# a_n129_n2308# a_n187_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X290 a_6291_n1310# a_6191_n2308# a_6133_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X291 a_n5875_n2220# a_n5975_n2308# a_n6033_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X292 a_4553_1420# a_4453_n2308# a_4395_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X293 a_n4927_1420# a_n5027_n2308# a_n5085_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X294 a_445_n2220# a_345_n2308# a_287_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X295 a_n4453_1420# a_n4553_n2308# a_n4611_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X296 a_n2557_510# a_n2657_n2308# a_n2715_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X297 a_n3505_n2220# a_n3605_n2308# a_n3663_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X298 a_5027_n400# a_4927_n2308# a_4869_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X299 a_1077_510# a_977_n2308# a_919_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X300 a_n2083_510# a_n2183_n2308# a_n2241_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X301 a_n4769_510# a_n4869_n2308# a_n4927_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X302 a_n4137_n2220# a_n4237_n2308# a_n4295_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X303 a_n5875_n1310# a_n5975_n2308# a_n6033_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X304 a_445_n1310# a_345_n2308# a_287_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X305 a_2025_510# a_1925_n2308# a_1867_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X306 a_n345_n400# a_n445_n2308# a_n503_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X307 a_n4295_510# a_n4395_n2308# a_n4453_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X308 a_n3505_n1310# a_n3605_n2308# a_n3663_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X309 a_5343_n400# a_5243_n2308# a_5185_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X310 a_2499_n400# a_2399_n2308# a_2341_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X311 a_1551_510# a_1451_n2308# a_1393_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X312 a_n2399_n400# a_n2499_n2308# a_n2557_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X313 a_n5243_n400# a_n5343_n2308# a_n5401_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X314 a_n4137_n1310# a_n4237_n2308# a_n4295_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X315 a_n3663_n2220# a_n3763_n2308# a_n3821_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X316 a_3763_510# a_3663_n2308# a_3605_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X317 a_n4295_n2220# a_n4395_n2308# a_n4453_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X318 a_n2715_510# a_n2815_n2308# a_n2873_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X319 a_919_n2220# a_819_n2308# a_761_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X320 a_5975_510# a_5875_n2308# a_5817_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X321 a_n3979_1420# a_n4079_n2308# a_n4137_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X322 a_3921_n2220# a_3821_n2308# a_3763_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X323 a_129_n400# a_29_n2308# a_n29_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X324 a_1235_1420# a_1135_n2308# a_1077_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X325 a_n2241_510# a_n2341_n2308# a_n2399_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X326 a_n1135_1420# a_n1235_n2308# a_n1293_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X327 a_n1925_n2220# a_n2025_n2308# a_n2083_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X328 a_n3663_n1310# a_n3763_n2308# a_n3821_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X329 a_4553_n2220# a_4453_n2308# a_4395_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X330 a_4079_n400# a_3979_n2308# a_3921_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X331 a_761_510# a_661_n2308# a_603_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X332 a_1709_n400# a_1609_n2308# a_1551_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X333 a_n4453_510# a_n4553_n2308# a_n4611_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X334 a_n4295_n1310# a_n4395_n2308# a_n4453_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X335 a_n1609_n400# a_n1709_n2308# a_n1767_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X336 a_919_n1310# a_819_n2308# a_761_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X337 a_5185_n2220# a_5085_n2308# a_5027_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X338 a_445_n400# a_345_n2308# a_287_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X339 a_3921_n1310# a_3821_n2308# a_3763_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X340 a_3289_510# a_3189_n2308# a_3131_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X341 a_1077_n2220# a_977_n2308# a_919_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X342 a_n1925_n1310# a_n2025_n2308# a_n2083_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X343 a_5659_1420# a_5559_n2308# a_5501_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X344 a_n1451_n2220# a_n1551_n2308# a_n1609_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X345 a_n5559_1420# a_n5659_n2308# a_n5717_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X346 a_4553_n1310# a_4453_n2308# a_4395_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X347 a_4395_n400# a_4295_n2308# a_4237_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X348 a_3921_510# a_3821_n2308# a_3763_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X349 a_2815_1420# a_2715_n2308# a_2657_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X350 a_n4295_n400# a_n4395_n2308# a_n4453_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X351 a_n6191_510# a_n6291_n2308# a_n6349_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X352 a_n2715_1420# a_n2815_n2308# a_n2873_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X353 a_1551_n400# a_1451_n2308# a_1393_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X354 a_n2083_n2220# a_n2183_n2308# a_n2241_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X355 a_n1925_n400# a_n2025_n2308# a_n2083_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X356 a_5185_n1310# a_5085_n2308# a_5027_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X357 a_n1451_n400# a_n1551_n2308# a_n1609_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X358 a_n4769_n2220# a_n4869_n2308# a_n4927_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X359 a_287_510# a_187_n2308# a_129_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X360 a_1709_510# a_1609_n2308# a_1551_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X361 a_1077_n1310# a_977_n2308# a_919_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X362 a_n3979_510# a_n4079_n2308# a_n4137_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X363 a_n1451_n1310# a_n1551_n2308# a_n1609_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X364 a_2341_n2220# a_2241_n2308# a_2183_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X365 a_1235_510# a_1135_n2308# a_1077_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X366 a_3131_1420# a_3031_n2308# a_2973_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X367 a_5027_n2220# a_4927_n2308# a_4869_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X368 a_n4611_510# a_n4711_n2308# a_n4769_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X369 a_n3031_1420# a_n3131_n2308# a_n3189_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X370 a_n2083_n1310# a_n2183_n2308# a_n2241_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X371 a_5975_n400# a_5875_n2308# a_5817_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X372 a_n4769_n1310# a_n4869_n2308# a_n4927_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X373 a_n5875_n400# a_n5975_n2308# a_n6033_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X374 a_5659_n2220# a_5559_n2308# a_5501_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X375 a_3605_n400# a_3505_n2308# a_3447_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X376 a_3447_510# a_3347_n2308# a_3289_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X377 a_n3505_n400# a_n3605_n2308# a_n3663_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X378 a_n345_n2220# a_n445_n2308# a_n503_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X379 a_2341_n1310# a_2241_n2308# a_2183_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X380 a_5659_510# a_5559_n2308# a_5501_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X381 a_5027_n1310# a_4927_n2308# a_4869_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X382 a_919_510# a_819_n2308# a_761_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X383 a_n1925_510# a_n2025_n2308# a_n2083_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X384 a_6291_n400# a_6191_n2308# a_6133_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=1.16e+12p pd=8.58e+06u as=0p ps=0u w=4e+06u l=500000u
X385 a_1867_1420# a_1767_n2308# a_1709_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X386 a_5185_510# a_5085_n2308# a_5027_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X387 a_4711_1420# a_4611_n2308# a_4553_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X388 a_n2557_n2220# a_n2657_n2308# a_n2715_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X389 a_n6191_n400# a_n6291_n2308# a_n6349_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=1.16e+12p ps=8.58e+06u w=4e+06u l=500000u
X390 a_n1767_1420# a_n1867_n2308# a_n1925_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X391 a_n4611_1420# a_n4711_n2308# a_n4769_1420# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X392 a_5659_n1310# a_5559_n2308# a_5501_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X393 a_445_510# a_345_n2308# a_287_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X394 a_n977_n400# a_n1077_n2308# a_n1135_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X395 a_n4137_510# a_n4237_n2308# a_n4295_510# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X396 a_n345_n1310# a_n445_n2308# a_n503_n1310# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X397 a_n3189_n2220# a_n3289_n2308# a_n3347_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X398 a_2815_n2220# a_2715_n2308# a_2657_n2220# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
X399 a_1077_n400# a_977_n2308# a_919_n400# a_n6483_n2442# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=4e+06u l=500000u
.ends

.subckt large_nmos_g5d10 m1_6740_198# m1_7688_198# m1_3896_198# m1_2948_198# m1_2000_198#
+ m1_11796_198# m1_10848_198# m1_8320_198# m1_9268_198# m1_736_198# m1_5476_198# m1_4528_198#
+ m1_9900_198# m1_1684_198# m1_12428_198# m1_7056_198# m1_6108_198# m1_3264_198# m1_2316_198#
+ m1_n124_2112# m1_11164_198# m1_10216_198# m1_9584_198# m1_8636_198# m1_5792_198#
+ m1_4844_198# m1_104_198# m1_1052_198# m1_7372_198# m1_6424_198# m1_3580_198# m1_2632_198#
+ m1_12738_198# m1_11480_198# m1_10532_198# m1_8952_198# m1_8004_198# m1_420_198#
+ m1_5160_198# m1_4212_198# m1_12112_198# m1_1368_198# VSUBS
Xsky130_fd_pr__nfet_g5v0d10v5_KBPKF4_0 VSUBS VSUBS m1_5160_198# m1_n124_2112# m1_8952_198#
+ m1_5792_198# VSUBS m1_n124_2112# m1_n124_2112# m1_6740_198# m1_4528_198# m1_n124_2112#
+ VSUBS m1_4212_198# VSUBS m1_n124_2112# VSUBS m1_2000_198# m1_n124_2112# m1_5792_198#
+ m1_7688_198# m1_9900_198# m1_n124_2112# m1_12112_198# VSUBS VSUBS m1_9268_198# VSUBS
+ VSUBS VSUBS m1_n124_2112# VSUBS VSUBS m1_n124_2112# m1_10216_198# VSUBS m1_9268_198#
+ m1_n124_2112# VSUBS VSUBS m1_5476_198# VSUBS VSUBS VSUBS m1_n124_2112# m1_n124_2112#
+ VSUBS m1_420_198# VSUBS m1_10848_198# m1_3580_198# m1_n124_2112# m1_11480_198# VSUBS
+ m1_1052_198# m1_8320_198# VSUBS m1_n124_2112# m1_8636_198# m1_2000_198# m1_5476_198#
+ m1_n124_2112# m1_8636_198# m1_10848_198# m1_7372_198# VSUBS m1_n124_2112# VSUBS
+ VSUBS m1_n124_2112# m1_4212_198# m1_n124_2112# m1_6424_198# VSUBS m1_1052_198# m1_n124_2112#
+ VSUBS m1_104_198# VSUBS m1_n124_2112# m1_104_198# VSUBS m1_n124_2112# VSUBS VSUBS
+ m1_2316_198# VSUBS m1_n124_2112# m1_3896_198# VSUBS VSUBS m1_8952_198# m1_4844_198#
+ VSUBS m1_1684_198# VSUBS VSUBS VSUBS m1_12738_198# m1_3896_198# m1_2632_198# m1_n124_2112#
+ m1_n124_2112# VSUBS m1_11796_198# m1_10532_198# VSUBS m1_11796_198# m1_9268_198#
+ m1_n124_2112# m1_9584_198# VSUBS VSUBS m1_11796_198# m1_9584_198# m1_6424_198# VSUBS
+ VSUBS VSUBS VSUBS VSUBS m1_8004_198# VSUBS m1_3264_198# m1_n124_2112# VSUBS VSUBS
+ VSUBS m1_n124_2112# VSUBS m1_8952_198# m1_11480_198# VSUBS m1_n124_2112# m1_n124_2112#
+ VSUBS m1_8952_198# VSUBS m1_8004_198# VSUBS m1_2000_198# m1_12112_198# m1_10216_198#
+ m1_12428_198# m1_7056_198# m1_7056_198# m1_12738_198# VSUBS m1_7056_198# VSUBS m1_4212_198#
+ m1_9900_198# m1_n124_2112# VSUBS m1_3580_198# VSUBS m1_1368_198# m1_7688_198# VSUBS
+ VSUBS m1_11480_198# m1_n124_2112# m1_2316_198# VSUBS VSUBS VSUBS m1_6108_198# m1_n124_2112#
+ VSUBS VSUBS m1_4844_198# VSUBS VSUBS m1_5160_198# VSUBS VSUBS m1_2316_198# m1_1684_198#
+ m1_104_198# VSUBS VSUBS VSUBS m1_7372_198# m1_n124_2112# m1_n124_2112# m1_3896_198#
+ m1_7688_198# VSUBS m1_9900_198# m1_9584_198# m1_12112_198# m1_11796_198# VSUBS m1_n124_2112#
+ VSUBS m1_6108_198# VSUBS VSUBS VSUBS m1_11164_198# VSUBS m1_12428_198# m1_n124_2112#
+ m1_9584_198# VSUBS VSUBS m1_1052_198# m1_5476_198# VSUBS VSUBS VSUBS m1_6740_198#
+ m1_10216_198# VSUBS m1_n124_2112# VSUBS m1_3896_198# VSUBS m1_10532_198# m1_736_198#
+ m1_1684_198# VSUBS m1_8004_198# m1_n124_2112# m1_1368_198# VSUBS m1_8320_198# VSUBS
+ m1_n124_2112# m1_n124_2112# m1_8636_198# VSUBS m1_n124_2112# m1_10848_198# VSUBS
+ m1_3580_198# VSUBS m1_4528_198# m1_12112_198# m1_n124_2112# VSUBS VSUBS VSUBS m1_7056_198#
+ VSUBS m1_6424_198# m1_6424_198# m1_9900_198# VSUBS m1_736_198# m1_n124_2112# VSUBS
+ VSUBS m1_11164_198# VSUBS m1_3580_198# VSUBS VSUBS m1_7688_198# VSUBS m1_5160_198#
+ m1_2948_198# m1_n124_2112# VSUBS m1_n124_2112# VSUBS m1_8320_198# m1_6740_198# m1_n124_2112#
+ VSUBS m1_n124_2112# VSUBS VSUBS VSUBS m1_12112_198# m1_1368_198# VSUBS VSUBS m1_2948_198#
+ m1_736_198# VSUBS VSUBS m1_7372_198# m1_420_198# VSUBS m1_n124_2112# m1_9268_198#
+ VSUBS VSUBS m1_n124_2112# m1_n124_2112# m1_9584_198# m1_8320_198# VSUBS m1_11796_198#
+ VSUBS VSUBS VSUBS VSUBS m1_n124_2112# VSUBS VSUBS m1_12428_198# m1_n124_2112# m1_1052_198#
+ m1_5792_198# m1_4844_198# m1_10216_198# m1_6740_198# m1_3264_198# VSUBS VSUBS m1_6740_198#
+ VSUBS m1_4528_198# m1_2000_198# VSUBS VSUBS m1_2948_198# m1_4212_198# m1_8004_198#
+ VSUBS m1_2000_198# m1_2632_198# m1_n124_2112# m1_n124_2112# m1_7372_198# m1_3264_198#
+ VSUBS m1_8004_198# m1_10216_198# m1_12428_198# VSUBS m1_n124_2112# VSUBS m1_12738_198#
+ VSUBS VSUBS VSUBS VSUBS m1_6424_198# VSUBS VSUBS VSUBS m1_736_198# VSUBS VSUBS m1_6108_198#
+ m1_n124_2112# m1_5792_198# VSUBS m1_3580_198# VSUBS m1_2948_198# VSUBS VSUBS VSUBS
+ m1_6108_198# m1_8320_198# m1_n124_2112# VSUBS m1_4844_198# m1_7372_198# m1_4528_198#
+ m1_10848_198# m1_2316_198# m1_104_198# VSUBS m1_9900_198# m1_1368_198# VSUBS VSUBS
+ m1_11164_198# m1_1052_198# VSUBS m1_10532_198# VSUBS m1_n124_2112# VSUBS VSUBS VSUBS
+ VSUBS VSUBS VSUBS m1_11164_198# m1_420_198# VSUBS m1_n124_2112# m1_12738_198# m1_n124_2112#
+ m1_5476_198# VSUBS VSUBS VSUBS m1_5160_198# m1_n124_2112# m1_3896_198# VSUBS m1_4844_198#
+ m1_1684_198# VSUBS VSUBS VSUBS m1_4212_198# m1_5792_198# VSUBS m1_1368_198# m1_n124_2112#
+ m1_2632_198# m1_2632_198# m1_10532_198# VSUBS m1_n124_2112# VSUBS m1_3264_198# VSUBS
+ m1_9268_198# VSUBS m1_n124_2112# m1_12428_198# VSUBS VSUBS m1_n124_2112# VSUBS VSUBS
+ VSUBS m1_3264_198# VSUBS m1_n124_2112# VSUBS m1_420_198# VSUBS VSUBS VSUBS m1_5160_198#
+ m1_10848_198# m1_n124_2112# m1_6108_198# m1_n124_2112# m1_11480_198# VSUBS VSUBS
+ m1_8952_198# m1_8636_198# VSUBS m1_n124_2112# m1_5476_198# VSUBS m1_n124_2112# m1_n124_2112#
+ VSUBS m1_n124_2112# VSUBS m1_n124_2112# m1_n124_2112# m1_2948_198# VSUBS m1_7056_198#
+ m1_4528_198# m1_736_198# m1_8636_198# m1_2632_198# VSUBS m1_n124_2112# m1_7688_198#
+ m1_11164_198# m1_420_198# VSUBS m1_11480_198# m1_10532_198# m1_n124_2112# m1_104_198#
+ VSUBS m1_n124_2112# VSUBS VSUBS VSUBS m1_2316_198# VSUBS m1_n124_2112# VSUBS VSUBS
+ m1_12738_198# m1_n124_2112# m1_n124_2112# m1_1684_198# sky130_fd_pr__nfet_g5v0d10v5_KBPKF4
.ends

.subckt sky130_fd_pr__nfet_g5v0d10v5_U5GC69 a_445_n1185# a_603_n565# a_n1135_n875#
+ a_n345_985# a_919_n1185# a_1235_675# a_445_985# a_n977_n875# a_n1135_675# a_1077_n1185#
+ a_1235_1295# a_n503_n255# a_129_n255# a_761_1295# a_287_n1185# a_n977_n1495# a_n1293_n255#
+ a_n187_365# a_1551_n1185# a_287_365# a_1235_n565# a_n129_n1583# a_n503_n875# a_445_55#
+ a_n1293_n875# a_129_n875# a_761_n565# a_761_n1185# a_n187_985# a_n29_n1185# a_n503_55#
+ a_1077_675# a_n977_675# a_287_985# a_n29_1295# a_n1235_n1583# a_1393_1295# a_1393_n1185#
+ a_n603_n1583# a_n661_n255# a_287_n255# a_n29_n565# a_n819_365# a_129_675# a_n1077_n1583#
+ a_919_365# a_n187_1295# a_1393_n565# a_n661_n875# a_1077_55# a_n1135_55# a_503_n1583#
+ a_287_n875# a_n1451_n255# a_n445_n1583# a_n1135_n1185# a_n819_985# a_n919_n1583#
+ a_1135_n1583# a_n1551_n1583# a_n1609_n1185# a_n661_365# a_n1609_675# a_919_985#
+ a_n187_n565# a_n1451_n875# a_n503_n1185# a_761_365# a_919_n255# a_345_n1583# a_1551_1295#
+ a_n287_n1583# a_819_n1583# a_n29_675# a_n661_985# a_1551_675# a_n1451_675# a_761_985#
+ a_n819_1295# a_n1393_n1583# a_445_n255# a_603_55# a_919_n875# a_n345_n1185# a_n761_n1583#
+ a_n819_n1185# a_n345_1295# a_187_n1583# a_1551_n565# a_n1451_n1185# a_n503_675#
+ a_n1609_1295# a_603_675# a_1451_n1583# a_n819_n565# a_445_n875# a_n819_55# a_n661_55#
+ a_n187_n1185# a_129_n1495# a_n1135_1295# a_661_n1583# a_1077_n255# a_n345_n565#
+ a_n977_1295# a_n1609_n565# a_n1293_n1185# a_1393_675# a_n1293_675# a_1235_55# a_1293_n1583#
+ a_n661_n1185# a_603_n1495# a_1077_n875# a_n1135_n565# a_603_n255# a_n345_675# a_1235_n1495#
+ a_n1293_55# a_1235_365# a_445_675# a_n977_n565# a_n1135_365# a_977_n1583# a_n503_1295#
+ a_129_1295# a_445_n1495# a_n1293_1295# a_603_n875# a_n977_n1185# a_919_n1495# a_1235_985#
+ a_n1135_985# a_1077_n1495# a_1235_n255# a_n503_n565# a_129_n565# a_919_55# a_n1293_n565#
+ a_287_n1495# a_761_n255# a_761_55# a_n187_675# a_1551_n1495# a_129_55# a_1077_365#
+ a_n977_365# a_287_675# a_1235_n875# a_n661_1295# a_287_1295# a_761_n875# a_761_n1495#
+ a_n29_n1495# a_n977_55# a_1077_985# a_129_365# a_n977_985# a_n29_n255# a_1393_n1495#
+ a_n187_55# a_n1451_1295# a_1393_n255# a_n661_n565# a_n1609_55# a_287_n565# a_n1451_55#
+ a_n29_n875# a_1393_55# a_n819_675# a_129_985# a_919_675# a_1393_n875# a_n1609_365#
+ a_n187_n255# a_n1451_n565# a_919_1295# a_n1135_n1495# a_n29_55# a_n29_365# a_n661_675#
+ a_n1609_985# a_n1609_n1495# a_445_1295# a_n187_n875# a_n503_n1495# a_1551_365# a_n1451_365#
+ a_761_675# a_919_n565# a_n29_985# a_1551_n255# a_n503_365# a_1551_985# a_603_365#
+ a_n1451_985# a_445_n565# a_n819_n255# a_n1743_n1717# a_n345_n1495# a_1077_1295#
+ a_129_n1185# a_n819_n1495# a_287_55# a_1551_n875# a_n1451_n1495# a_n503_985# a_29_n1583#
+ a_n345_n255# a_n819_n875# a_n345_55# a_603_985# a_n1609_n255# a_1393_365# a_n1293_365#
+ a_603_n1185# a_n187_n1495# a_1551_55# a_1077_n565# a_603_1295# a_n345_n875# a_n1135_n255#
+ a_n345_365# a_n1609_n875# a_1235_n1185# a_n1293_n1495# a_1393_985# a_n977_n255#
+ a_445_365# a_n1293_985# a_n661_n1495#
X0 a_n1135_1295# a_n1235_n1583# a_n1293_1295# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X1 a_1235_1295# a_1135_n1583# a_1077_1295# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X2 a_129_675# a_29_n1583# a_n29_675# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X3 a_n1451_365# a_n1551_n1583# a_n1609_365# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X4 a_n29_n1185# a_n129_n1583# a_n187_n1185# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X5 a_n1135_55# a_n1235_n1583# a_n1293_55# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X6 a_445_n1495# a_345_n1583# a_287_n1495# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X7 a_1551_n1185# a_1451_n1583# a_1393_n1185# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X8 a_287_n875# a_187_n1583# a_129_n875# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X9 a_1235_n255# a_1135_n1583# a_1077_n255# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X10 a_n1135_n255# a_n1235_n1583# a_n1293_n255# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X11 a_1393_985# a_1293_n1583# a_1235_985# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X12 a_n187_675# a_n287_n1583# a_n345_675# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X13 a_129_55# a_29_n1583# a_n29_55# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X14 a_1393_n875# a_1293_n1583# a_1235_n875# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X15 a_n1293_n875# a_n1393_n1583# a_n1451_n875# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X16 a_1393_55# a_1293_n1583# a_1235_55# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X17 a_n819_n565# a_n919_n1583# a_n977_n565# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X18 a_n977_365# a_n1077_n1583# a_n1135_365# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X19 a_n187_n1185# a_n287_n1583# a_n345_n1185# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X20 a_n29_55# a_n129_n1583# a_n187_55# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X21 a_1077_985# a_977_n1583# a_919_985# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X22 a_n819_675# a_n919_n1583# a_n977_675# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X23 a_919_n1495# a_819_n1583# a_761_n1495# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X24 a_n661_n565# a_n761_n1583# a_n819_n565# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=500000u
X25 a_n345_675# a_n445_n1583# a_n503_675# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X26 a_1551_985# a_1451_n1583# a_1393_985# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=500000u
X27 a_n1135_365# a_n1235_n1583# a_n1293_365# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X28 a_919_n565# a_819_n1583# a_761_n565# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X29 a_1077_n1495# a_977_n1583# a_919_n1495# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=500000u
X30 a_n1451_n1495# a_n1551_n1583# a_n1609_n1495# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X31 a_n977_55# a_n1077_n1583# a_n1135_55# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=500000u
X32 a_1235_55# a_1135_n1583# a_1077_55# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X33 a_n345_n875# a_n445_n1583# a_n503_n875# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X34 a_761_985# a_661_n1583# a_603_985# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X35 a_761_n565# a_661_n1583# a_603_n565# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X36 a_n187_n565# a_n287_n1583# a_n345_n565# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X37 a_n503_675# a_n603_n1583# a_n661_675# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X38 a_129_n1185# a_29_n1583# a_n29_n1185# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=500000u
X39 a_129_n875# a_29_n1583# a_n29_n875# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X40 a_n661_365# a_n761_n1583# a_n819_365# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X41 a_n345_n1495# a_n445_n1583# a_n503_n1495# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X42 a_287_985# a_187_n1583# a_129_985# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X43 a_761_55# a_661_n1583# a_603_55# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X44 a_n29_675# a_n129_n1583# a_n187_675# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X45 a_1235_985# a_1135_n1583# a_1077_985# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X46 a_129_365# a_29_n1583# a_n29_365# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X47 a_445_n875# a_345_n1583# a_287_n875# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=500000u
X48 a_445_n1185# a_345_n1583# a_287_n1185# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X49 a_287_n565# a_187_n1583# a_129_n565# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X50 a_n819_1295# a_n919_n1583# a_n977_1295# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X51 a_1551_n875# a_1451_n1583# a_1393_n875# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=500000u
X52 a_919_985# a_819_n1583# a_761_985# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X53 a_n187_365# a_n287_n1583# a_n345_365# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X54 a_n1451_n875# a_n1551_n1583# a_n1609_n875# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X55 a_1393_n565# a_1293_n1583# a_1235_n565# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X56 a_1393_675# a_1293_n1583# a_1235_675# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X57 a_n1293_n565# a_n1393_n1583# a_n1451_n565# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X58 a_n661_1295# a_n761_n1583# a_n819_1295# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=500000u
X59 a_445_985# a_345_n1583# a_287_985# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=500000u
X60 a_n819_n255# a_n919_n1583# a_n977_n255# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X61 a_n819_n1495# a_n919_n1583# a_n977_n1495# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X62 a_1077_675# a_977_n1583# a_919_675# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X63 a_n977_n1495# a_n1077_n1583# a_n1135_n1495# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X64 a_n661_n255# a_n761_n1583# a_n819_n255# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=500000u
X65 a_n819_365# a_n919_n1583# a_n977_365# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X66 a_919_n1185# a_819_n1583# a_761_n1185# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X67 a_919_1295# a_819_n1583# a_761_1295# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X68 a_n345_365# a_n445_n1583# a_n503_365# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X69 a_603_55# a_503_n1583# a_445_55# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X70 a_1235_n1495# a_1135_n1583# a_1077_n1495# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=500000u
X71 a_1551_675# a_1451_n1583# a_1393_675# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=500000u
X72 a_n977_n875# a_n1077_n1583# a_n1135_n875# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X73 a_603_985# a_503_n1583# a_445_985# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X74 a_919_n255# a_819_n1583# a_761_n255# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X75 a_n187_1295# a_n287_n1583# a_n345_1295# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X76 a_761_1295# a_661_n1583# a_603_1295# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X77 a_1077_n1185# a_977_n1583# a_919_n1185# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=500000u
X78 a_1077_n875# a_977_n1583# a_919_n875# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X79 a_n1451_n1185# a_n1551_n1583# a_n1609_n1185# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X80 a_n503_n875# a_n603_n1583# a_n661_n875# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X81 a_1393_n1495# a_1293_n1583# a_1235_n1495# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=500000u
X82 a_n345_n565# a_n445_n1583# a_n503_n565# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X83 a_761_675# a_661_n1583# a_603_675# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X84 a_603_n1495# a_503_n1583# a_445_n1495# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=500000u
X85 a_761_n255# a_661_n1583# a_603_n255# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X86 a_n187_n255# a_n287_n1583# a_n345_n255# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X87 a_n503_365# a_n603_n1583# a_n661_365# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X88 a_1077_55# a_977_n1583# a_919_55# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X89 a_n345_n1185# a_n445_n1583# a_n503_n1185# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X90 a_129_n565# a_29_n1583# a_n29_n565# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X91 a_287_1295# a_187_n1583# a_129_1295# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X92 a_287_675# a_187_n1583# a_129_675# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=500000u
X93 a_761_n1495# a_661_n1583# a_603_n1495# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X94 a_603_n875# a_503_n1583# a_445_n875# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=500000u
X95 a_1235_675# a_1135_n1583# a_1077_675# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X96 a_n29_365# a_n129_n1583# a_n187_365# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X97 a_n29_n875# a_n129_n1583# a_n187_n875# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X98 a_1393_1295# a_1293_n1583# a_1235_1295# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=500000u
X99 a_n1293_985# a_n1393_n1583# a_n1451_985# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X100 a_445_n565# a_345_n1583# a_287_n565# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=500000u
X101 a_n1293_1295# a_n1393_n1583# a_n1451_1295# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X102 a_287_n255# a_187_n1583# a_129_n255# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X103 a_445_55# a_345_n1583# a_287_55# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X104 a_1551_n565# a_1451_n1583# a_1393_n565# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=500000u
X105 a_n1451_n565# a_n1551_n1583# a_n1609_n565# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X106 a_919_675# a_819_n1583# a_761_675# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X107 a_1393_n255# a_1293_n1583# a_1235_n255# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=500000u
X108 a_1393_365# a_1293_n1583# a_1235_365# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X109 a_n1293_n255# a_n1393_n1583# a_n1451_n255# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X110 a_445_675# a_345_n1583# a_287_675# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=500000u
X111 a_n819_n1185# a_n919_n1583# a_n977_n1185# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X112 a_n661_55# a_n761_n1583# a_n819_55# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X113 a_919_55# a_819_n1583# a_761_55# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X114 a_n1451_985# a_n1551_n1583# a_n1609_985# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X115 a_1077_365# a_977_n1583# a_919_365# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X116 a_n977_n1185# a_n1077_n1583# a_n1135_n1185# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X117 a_1235_n875# a_1135_n1583# a_1077_n875# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X118 a_n1135_n875# a_n1235_n1583# a_n1293_n875# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X119 a_1551_365# a_1451_n1583# a_1393_365# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=500000u
X120 a_1235_n1185# a_1135_n1583# a_1077_n1185# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=500000u
X121 a_n977_n565# a_n1077_n1583# a_n1135_n565# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X122 a_n345_1295# a_n445_n1583# a_n503_1295# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X123 a_603_675# a_503_n1583# a_445_675# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X124 a_n977_985# a_n1077_n1583# a_n1135_985# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X125 a_n503_n1495# a_n603_n1583# a_n661_n1495# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X126 a_1077_n565# a_977_n1583# a_919_n565# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=500000u
X127 a_n503_n565# a_n603_n1583# a_n661_n565# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X128 a_287_n1495# a_187_n1583# a_129_n1495# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X129 a_1393_n1185# a_1293_n1583# a_1235_n1185# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X130 a_n345_n255# a_n445_n1583# a_n503_n255# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X131 a_761_365# a_661_n1583# a_603_365# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X132 a_129_1295# a_29_n1583# a_n29_1295# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X133 a_603_n1185# a_503_n1583# a_445_n1185# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=500000u
X134 a_287_55# a_187_n1583# a_129_55# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X135 a_n503_55# a_n603_n1583# a_n661_55# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=500000u
X136 a_n661_n1495# a_n761_n1583# a_n819_n1495# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X137 a_n1135_985# a_n1235_n1583# a_n1293_985# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X138 a_129_n255# a_29_n1583# a_n29_n255# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X139 a_445_1295# a_345_n1583# a_287_1295# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=500000u
X140 a_287_365# a_187_n1583# a_129_365# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=500000u
X141 a_761_n1185# a_661_n1583# a_603_n1185# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X142 a_603_n565# a_503_n1583# a_445_n565# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X143 a_n29_n565# a_n129_n1583# a_n187_n565# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X144 a_n1451_1295# a_n1551_n1583# a_n1609_1295# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X145 a_1551_1295# a_1451_n1583# a_1393_1295# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=500000u
X146 a_1235_365# a_1135_n1583# a_1077_365# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X147 a_445_n255# a_345_n1583# a_287_n255# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=500000u
X148 a_n1293_675# a_n1393_n1583# a_n1451_675# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X149 a_n1135_n1495# a_n1235_n1583# a_n1293_n1495# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X150 a_n1451_n255# a_n1551_n1583# a_n1609_n255# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X151 a_1551_n255# a_1451_n1583# a_1393_n255# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=500000u
X152 a_919_365# a_819_n1583# a_761_365# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X153 a_n1451_55# a_n1551_n1583# a_n1609_55# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X154 a_n661_985# a_n761_n1583# a_n819_985# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X155 a_445_365# a_345_n1583# a_287_365# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=500000u
X156 a_n1293_n1495# a_n1393_n1583# a_n1451_n1495# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X157 a_129_985# a_29_n1583# a_n29_985# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X158 a_n1451_675# a_n1551_n1583# a_n1609_675# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X159 a_1551_n1495# a_1451_n1583# a_1393_n1495# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=500000u
X160 a_n29_n1495# a_n129_n1583# a_n187_n1495# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X161 a_n977_1295# a_n1077_n1583# a_n1135_1295# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X162 a_1235_n565# a_1135_n1583# a_1077_n565# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X163 a_n1135_n565# a_n1235_n1583# a_n1293_n565# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X164 a_1077_1295# a_977_n1583# a_919_1295# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X165 a_n187_985# a_n287_n1583# a_n345_985# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X166 a_n345_55# a_n445_n1583# a_n503_55# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=500000u
X167 a_n503_1295# a_n603_n1583# a_n661_1295# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X168 a_n977_n255# a_n1077_n1583# a_n1135_n255# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X169 a_n819_n875# a_n919_n1583# a_n977_n875# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=500000u
X170 a_603_365# a_503_n1583# a_445_365# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X171 a_n187_n1495# a_n287_n1583# a_n345_n1495# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X172 a_n977_675# a_n1077_n1583# a_n1135_675# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X173 a_n503_n1185# a_n603_n1583# a_n661_n1185# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X174 a_1077_n255# a_977_n1583# a_919_n255# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X175 a_n819_55# a_n919_n1583# a_n977_55# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X176 a_n503_n255# a_n603_n1583# a_n661_n255# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X177 a_287_n1185# a_187_n1583# a_129_n1185# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X178 a_n661_n875# a_n761_n1583# a_n819_n875# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X179 a_n819_985# a_n919_n1583# a_n977_985# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X180 a_n345_985# a_n445_n1583# a_n503_985# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X181 a_n661_n1185# a_n761_n1583# a_n819_n1185# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X182 a_n29_1295# a_n129_n1583# a_n187_1295# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X183 a_603_1295# a_503_n1583# a_445_1295# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X184 a_n1135_675# a_n1235_n1583# a_n1293_675# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X185 a_n1293_55# a_n1393_n1583# a_n1451_55# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X186 a_1551_55# a_1451_n1583# a_1393_55# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=500000u
X187 a_919_n875# a_819_n1583# a_761_n875# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X188 a_603_n255# a_503_n1583# a_445_n255# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X189 a_n29_n255# a_n129_n1583# a_n187_n255# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X190 a_761_n875# a_661_n1583# a_603_n875# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X191 a_n187_n875# a_n287_n1583# a_n345_n875# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X192 a_n503_985# a_n603_n1583# a_n661_985# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X193 a_n1293_365# a_n1393_n1583# a_n1451_365# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X194 a_129_n1495# a_29_n1583# a_n29_n1495# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X195 a_n1135_n1185# a_n1235_n1583# a_n1293_n1185# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X196 a_n187_55# a_n287_n1583# a_n345_55# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X197 a_n661_675# a_n761_n1583# a_n819_675# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X198 a_n1293_n1185# a_n1393_n1583# a_n1451_n1185# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
X199 a_n29_985# a_n129_n1583# a_n187_985# a_n1743_n1717# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=1e+06u l=500000u
.ends

.subckt mirrors VsMOS Ground Vo VpBJT VsBJT
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[0|0] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[1|0] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[2|0] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[3|0] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[4|0] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[5|0] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[6|0] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[7|0] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[8|0] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[9|0] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[0|1] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[1|1] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[2|1] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[3|1] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[4|1] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[5|1] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[6|1] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[7|1] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[8|1] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[9|1] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[0|2] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[1|2] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[2|2] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[3|2] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[4|2] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[5|2] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[6|2] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[7|2] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[8|2] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[9|2] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[0|3] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[1|3] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[2|3] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[3|3] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[4|3] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[5|3] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[6|3] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[7|3] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[8|3] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[9|3] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[0|4] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[1|4] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[2|4] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[3|4] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[4|4] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[5|4] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[6|4] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[7|4] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[8|4] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[9|4] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[0|5] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[1|5] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[2|5] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[3|5] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[4|5] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[5|5] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[6|5] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[7|5] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[8|5] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[9|5] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[0|6] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[1|6] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[2|6] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[3|6] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[4|6] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[5|6] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[6|6] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[7|6] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[8|6] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[9|6] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[0|7] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[1|7] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[2|7] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[3|7] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[4|7] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[5|7] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[6|7] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[7|7] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[8|7] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[9|7] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[0|8] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[1|8] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[2|8] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[3|8] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[4|8] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[5|8] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[6|8] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[7|8] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[8|8] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[9|8] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[0|9] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[1|9] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[2|9] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[3|9] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[4|9] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[5|9] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[6|9] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[7|9] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[8|9] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_2[9|9] VpBJT Ground VsBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__diode_pd2nw_11v0_VFE9GT_0 VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS
+ VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS
+ VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS
+ VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS Vo
+ VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS sky130_fd_pr__diode_pd2nw_11v0_VFE9GT
Xsky130_fd_pr__diode_pd2nw_11v0_6YHF4V_0 VsBJT VsBJT VsBJT VsBJT VsBJT VsBJT VsBJT
+ VsBJT VsBJT VsBJT VsBJT VsBJT Vo VsBJT VsBJT VsBJT VsBJT sky130_fd_pr__diode_pd2nw_11v0_6YHF4V
Xlarge_nmos_g5d10_0 VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS
+ VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VpMOS VsMOS VsMOS VsMOS VsMOS VsMOS
+ VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS
+ VsMOS VsMOS VsMOS Ground large_nmos_g5d10
Xlarge_nmos_g5d10_1 VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS
+ VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VpMOS VsMOS VsMOS VsMOS VsMOS VsMOS
+ VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS
+ VsMOS VsMOS VsMOS Ground large_nmos_g5d10
Xlarge_nmos_g5d10_2 VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS
+ VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VpMOS VsMOS VsMOS VsMOS VsMOS VsMOS
+ VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS
+ VsMOS VsMOS VsMOS Ground large_nmos_g5d10
Xlarge_nmos_g5d10_3 VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS
+ VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VpMOS VsMOS VsMOS VsMOS VsMOS VsMOS
+ VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS
+ VsMOS VsMOS VsMOS Ground large_nmos_g5d10
Xlarge_nmos_g5d10_4 VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS
+ VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VpMOS VsMOS VsMOS VsMOS VsMOS VsMOS
+ VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS
+ VsMOS VsMOS VsMOS Ground large_nmos_g5d10
Xlarge_nmos_g5d10_5 VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS
+ VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VpMOS VsMOS VsMOS VsMOS VsMOS VsMOS
+ VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS
+ VsMOS VsMOS VsMOS Ground large_nmos_g5d10
Xlarge_nmos_g5d10_6 VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS
+ VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VpMOS VsMOS VsMOS VsMOS VsMOS VsMOS
+ VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS
+ VsMOS VsMOS VsMOS Ground large_nmos_g5d10
Xlarge_nmos_g5d10_7 VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS
+ VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VpMOS VsMOS VsMOS VsMOS VsMOS VsMOS
+ VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS
+ VsMOS VsMOS VsMOS Ground large_nmos_g5d10
Xsky130_fd_pr__nfet_g5v0d10v5_U5GC69_0 Ground VpMOS Ground VpMOS VpMOS VpMOS Ground
+ VpMOS Ground Ground VpMOS Ground Ground Ground VpMOS VpMOS VpMOS Ground VpMOS VpMOS
+ VpMOS VpMOS Ground Ground VpMOS Ground Ground Ground Ground VpMOS Ground Ground
+ VpMOS VpMOS VpMOS VpMOS Ground Ground VpMOS VpMOS VpMOS VpMOS Ground Ground VpMOS
+ VpMOS Ground Ground VpMOS Ground Ground VpMOS VpMOS Ground VpMOS Ground Ground VpMOS
+ VpMOS VpMOS VpMOS VpMOS VpMOS VpMOS Ground Ground Ground Ground VpMOS VpMOS VpMOS
+ VpMOS VpMOS VpMOS VpMOS VpMOS Ground Ground Ground VpMOS Ground VpMOS VpMOS VpMOS
+ VpMOS Ground VpMOS VpMOS VpMOS Ground Ground VpMOS VpMOS VpMOS Ground Ground Ground
+ VpMOS Ground Ground Ground VpMOS Ground VpMOS VpMOS VpMOS VpMOS Ground VpMOS VpMOS
+ VpMOS VpMOS VpMOS Ground Ground VpMOS VpMOS VpMOS VpMOS VpMOS Ground VpMOS Ground
+ VpMOS Ground Ground Ground VpMOS VpMOS VpMOS VpMOS VpMOS Ground Ground VpMOS Ground
+ Ground VpMOS VpMOS VpMOS Ground Ground Ground VpMOS Ground Ground VpMOS VpMOS VpMOS
+ VpMOS VpMOS Ground Ground VpMOS VpMOS Ground Ground VpMOS VpMOS Ground Ground Ground
+ Ground VpMOS VpMOS VpMOS Ground VpMOS Ground Ground Ground VpMOS Ground VpMOS Ground
+ Ground VpMOS Ground VpMOS VpMOS VpMOS VpMOS VpMOS Ground Ground Ground VpMOS Ground
+ Ground VpMOS VpMOS VpMOS Ground VpMOS VpMOS Ground Ground Ground Ground VpMOS Ground
+ Ground Ground VpMOS VpMOS Ground Ground VpMOS VpMOS Ground VpMOS VpMOS VpMOS Ground
+ VpMOS VpMOS Ground VpMOS Ground VpMOS VpMOS Ground VpMOS VpMOS VpMOS VpMOS Ground
+ VpMOS Ground VpMOS VpMOS sky130_fd_pr__nfet_g5v0d10v5_U5GC69
Xlarge_nmos_g5d10_8 VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS
+ VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VpMOS VsMOS VsMOS VsMOS VsMOS VsMOS
+ VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS
+ VsMOS VsMOS VsMOS Ground large_nmos_g5d10
Xlarge_nmos_g5d10_9 VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS
+ VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VpMOS VsMOS VsMOS VsMOS VsMOS VsMOS
+ VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS VsMOS
+ VsMOS VsMOS VsMOS Ground large_nmos_g5d10
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_0 VpBJT m1_n11792_5896# VpBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_1[0|0] m1_n11792_5896# Ground VpBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_1[1|0] m1_n11792_5896# Ground VpBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_1[2|0] m1_n11792_5896# Ground VpBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_1[3|0] m1_n11792_5896# Ground VpBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_1[0|1] m1_n11792_5896# Ground VpBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_1[1|1] m1_n11792_5896# Ground VpBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_1[2|1] m1_n11792_5896# Ground VpBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_1[3|1] m1_n11792_5896# Ground VpBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_1[0|2] m1_n11792_5896# Ground VpBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_1[1|2] m1_n11792_5896# Ground VpBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_1[2|2] m1_n11792_5896# Ground VpBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_1[3|2] m1_n11792_5896# Ground VpBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_1[0|3] m1_n11792_5896# Ground VpBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_1[1|3] m1_n11792_5896# Ground VpBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_1[2|3] m1_n11792_5896# Ground VpBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
Xsky130_fd_pr__rf_npn_05v5_W1p00L2p00_1[3|3] m1_n11792_5896# Ground VpBJT Ground sky130_fd_pr__rf_npn_05v5_W1p00L2p00 m=1
.ends

.subckt sky130_fd_pr__pfet_01v8_UJR9GH a_n129_n500# a_63_n500# a_n225_n500# a_111_n597#
+ w_n455_n719# a_n273_n597# a_15_531# a_n33_n500# a_207_531# a_n81_n597# a_n177_531#
+ a_159_n500# a_n317_n500# a_255_n500#
X0 a_n33_n500# a_n81_n597# a_n129_n500# w_n455_n719# sky130_fd_pr__pfet_01v8 ad=1.65e+12p pd=1.066e+07u as=1.65e+12p ps=1.066e+07u w=5e+06u l=150000u
X1 a_255_n500# a_207_531# a_159_n500# w_n455_n719# sky130_fd_pr__pfet_01v8 ad=1.55e+12p pd=1.062e+07u as=1.65e+12p ps=1.066e+07u w=5e+06u l=150000u
X2 a_159_n500# a_111_n597# a_63_n500# w_n455_n719# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=1.65e+12p ps=1.066e+07u w=5e+06u l=150000u
X3 a_n225_n500# a_n273_n597# a_n317_n500# w_n455_n719# sky130_fd_pr__pfet_01v8 ad=1.65e+12p pd=1.066e+07u as=1.55e+12p ps=1.062e+07u w=5e+06u l=150000u
X4 a_63_n500# a_15_531# a_n33_n500# w_n455_n719# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=5e+06u l=150000u
X5 a_n129_n500# a_n177_531# a_n225_n500# w_n455_n719# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=5e+06u l=150000u
.ends

.subckt sky130_fd_pr__res_high_po_0p35_MTJUHY a_n165_n1097# a_n35_535# a_n35_n967#
X0 a_n35_n967# a_n35_535# a_n165_n1097# sky130_fd_pr__res_high_po_0p35 l=5.35e+06u
.ends

.subckt sky130_fd_pr__pfet_g5v0d10v5_5FQFS2 a_n108_64# a_n108_1704# a_n108_n1904#
+ a_n108_n920# a_50_n592# a_50_1376# a_50_2032# a_50_n1248# a_n108_1376# a_n108_n592#
+ a_n108_2032# a_n108_n1576# a_n108_n2232# a_50_n2560# a_n108_720# a_50_n264# a_50_1048#
+ a_n50_n2657# a_50_n1904# a_50_720# a_n108_392# w_n308_n2857# a_50_2360# a_n108_1048#
+ a_n108_n264# a_n108_n1248# a_50_64# a_50_n1576# a_50_392# a_50_n2232# a_50_n920#
+ a_50_1704# a_n108_2360# a_n108_n2560#
X0 a_50_2360# a_n50_n2657# a_n108_2360# w_n308_n2857# sky130_fd_pr__pfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X1 a_50_1704# a_n50_n2657# a_n108_1704# w_n308_n2857# sky130_fd_pr__pfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X2 a_50_n1576# a_n50_n2657# a_n108_n1576# w_n308_n2857# sky130_fd_pr__pfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X3 a_50_64# a_n50_n2657# a_n108_64# w_n308_n2857# sky130_fd_pr__pfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X4 a_50_n1904# a_n50_n2657# a_n108_n1904# w_n308_n2857# sky130_fd_pr__pfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X5 a_50_1048# a_n50_n2657# a_n108_1048# w_n308_n2857# sky130_fd_pr__pfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X6 a_50_392# a_n50_n2657# a_n108_392# w_n308_n2857# sky130_fd_pr__pfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X7 a_50_n264# a_n50_n2657# a_n108_n264# w_n308_n2857# sky130_fd_pr__pfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X8 a_50_2032# a_n50_n2657# a_n108_2032# w_n308_n2857# sky130_fd_pr__pfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X9 a_50_n1248# a_n50_n2657# a_n108_n1248# w_n308_n2857# sky130_fd_pr__pfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X10 a_50_720# a_n50_n2657# a_n108_720# w_n308_n2857# sky130_fd_pr__pfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X11 a_50_1376# a_n50_n2657# a_n108_1376# w_n308_n2857# sky130_fd_pr__pfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X12 a_50_n2232# a_n50_n2657# a_n108_n2232# w_n308_n2857# sky130_fd_pr__pfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X13 a_50_n920# a_n50_n2657# a_n108_n920# w_n308_n2857# sky130_fd_pr__pfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X14 a_50_n592# a_n50_n2657# a_n108_n592# w_n308_n2857# sky130_fd_pr__pfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
X15 a_50_n2560# a_n50_n2657# a_n108_n2560# w_n308_n2857# sky130_fd_pr__pfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=500000u
.ends

.subckt current_source out_current Vdd VSUBS
Xsky130_fd_pr__res_high_po_0p35_MTJUHY_0 VSUBS VSUBS m1_3902_2202# sky130_fd_pr__res_high_po_0p35_MTJUHY
Xsky130_fd_pr__pfet_g5v0d10v5_AJQB7U_0 m1_n1758_2874# out_current Vdd Vdd sky130_fd_pr__pfet_g5v0d10v5_AJQB7U
Xsky130_fd_pr__nfet_g5v0d10v5_RX3AJQ_0 m1_3902_2202# VSUBS m1_n1758_2874# m1_3806_2304#
+ sky130_fd_pr__nfet_g5v0d10v5_RX3AJQ
Xsky130_fd_pr__nfet_g5v0d10v5_RX3AJQ_1 VSUBS VSUBS m1_3806_2304# m1_3902_2202# sky130_fd_pr__nfet_g5v0d10v5_RX3AJQ
Xsky130_fd_pr__pfet_g5v0d10v5_5FQFS2_0 m1_3806_2304# m1_3806_2304# m1_3806_2304# m1_3806_2304#
+ Vdd Vdd Vdd Vdd m1_3806_2304# m1_3806_2304# m1_3806_2304# m1_3806_2304# m1_3806_2304#
+ Vdd m1_3806_2304# Vdd Vdd m1_n1758_2874# Vdd Vdd m1_3806_2304# Vdd Vdd m1_3806_2304#
+ m1_3806_2304# m1_3806_2304# Vdd Vdd Vdd Vdd Vdd Vdd m1_3806_2304# m1_3806_2304#
+ sky130_fd_pr__pfet_g5v0d10v5_5FQFS2
Xsky130_fd_pr__pfet_g5v0d10v5_5FQFS2_1 m1_n1758_2874# m1_n1758_2874# m1_n1758_2874#
+ m1_n1758_2874# Vdd Vdd Vdd Vdd m1_n1758_2874# m1_n1758_2874# m1_n1758_2874# m1_n1758_2874#
+ m1_n1758_2874# Vdd m1_n1758_2874# Vdd Vdd m1_n1758_2874# Vdd Vdd m1_n1758_2874#
+ Vdd Vdd m1_n1758_2874# m1_n1758_2874# m1_n1758_2874# Vdd Vdd Vdd Vdd Vdd Vdd m1_n1758_2874#
+ m1_n1758_2874# sky130_fd_pr__pfet_g5v0d10v5_5FQFS2
.ends

.subckt sky130_fd_pr__res_high_po_0p35_8W29VJ a_n35_973# a_n165_n1535# a_n35_n1405#
X0 a_n35_n1405# a_n35_973# a_n165_n1535# sky130_fd_pr__res_high_po_0p35 l=9.73e+06u
.ends

.subckt sky130_fd_pr__nfet_g5v0d10v5_8PFU4A a_100_n410# a_n292_n632# a_100_210# a_n158_n410#
+ a_n100_n498# a_100_n100# a_n158_210# a_n158_n100#
X0 a_100_210# a_n100_n498# a_n158_210# a_n292_n632# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=1e+06u
X1 a_100_n100# a_n100_n498# a_n158_n100# a_n292_n632# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=1e+06u
X2 a_100_n410# a_n100_n498# a_n158_n410# a_n292_n632# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=1e+06u
.ends

.subckt sky130_fd_pr__pfet_g5v0d10v5_QS9L5N a_n158_n992# a_n100_n1089# a_n158_592#
+ a_n158_n464# w_n358_n1289# a_n158_64# a_100_592# a_100_64# a_100_n992# a_100_n464#
X0 a_100_64# a_n100_n1089# a_n158_64# w_n358_n1289# sky130_fd_pr__pfet_g5v0d10v5 ad=5.8e+11p pd=4.58e+06u as=5.8e+11p ps=4.58e+06u w=2e+06u l=1e+06u
X1 a_100_n992# a_n100_n1089# a_n158_n992# w_n358_n1289# sky130_fd_pr__pfet_g5v0d10v5 ad=5.8e+11p pd=4.58e+06u as=5.8e+11p ps=4.58e+06u w=2e+06u l=1e+06u
X2 a_100_n464# a_n100_n1089# a_n158_n464# w_n358_n1289# sky130_fd_pr__pfet_g5v0d10v5 ad=5.8e+11p pd=4.58e+06u as=5.8e+11p ps=4.58e+06u w=2e+06u l=1e+06u
X3 a_100_592# a_n100_n1089# a_n158_592# w_n358_n1289# sky130_fd_pr__pfet_g5v0d10v5 ad=5.8e+11p pd=4.58e+06u as=5.8e+11p ps=4.58e+06u w=2e+06u l=1e+06u
.ends

.subckt sky130_fd_pr__nfet_g5v0d10v5_NQKU4A a_100_1140# a_100_n410# a_n158_1140# a_100_210#
+ a_n158_520# a_n158_n410# a_n292_n1562# a_100_830# a_n100_n1428# a_100_n1030# a_n158_n1340#
+ a_100_n100# a_100_n720# a_n158_210# a_n158_n100# a_n158_830# a_100_520# a_n158_n720#
+ a_n158_n1030# a_100_n1340#
X0 a_100_n720# a_n100_n1428# a_n158_n720# a_n292_n1562# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=1e+06u
X1 a_100_210# a_n100_n1428# a_n158_210# a_n292_n1562# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=1e+06u
X2 a_100_n1030# a_n100_n1428# a_n158_n1030# a_n292_n1562# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=1e+06u
X3 a_100_n100# a_n100_n1428# a_n158_n100# a_n292_n1562# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=1e+06u
X4 a_100_n410# a_n100_n1428# a_n158_n410# a_n292_n1562# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=1e+06u
X5 a_100_830# a_n100_n1428# a_n158_830# a_n292_n1562# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=1e+06u
X6 a_100_1140# a_n100_n1428# a_n158_1140# a_n292_n1562# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=1e+06u
X7 a_100_520# a_n100_n1428# a_n158_520# a_n292_n1562# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=1e+06u
X8 a_100_n1340# a_n100_n1428# a_n158_n1340# a_n292_n1562# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=1e+06u
.ends

.subckt sky130_fd_pr__pfet_g5v0d10v5_2JCT5W a_n100_n3993# a_100_n1256# a_n158_n2840#
+ a_n158_n728# a_n158_856# a_n158_328# a_n158_2968# a_n158_n2312# a_100_n200# a_n158_n3896#
+ a_100_2440# a_n158_n3368# a_n158_n1784# a_n158_n200# a_n158_n1256# a_100_3496# a_n158_2440#
+ a_100_n2840# a_100_856# a_100_1384# a_100_n2312# a_100_328# a_100_1912# a_n158_3496#
+ a_100_n3896# a_100_n728# a_n158_1384# a_100_n3368# a_100_n1784# a_n158_1912# a_100_2968#
+ w_n358_n4193#
X0 a_100_n728# a_n100_n3993# a_n158_n728# w_n358_n4193# sky130_fd_pr__pfet_g5v0d10v5 ad=5.8e+11p pd=4.58e+06u as=5.8e+11p ps=4.58e+06u w=2e+06u l=1e+06u
X1 a_100_856# a_n100_n3993# a_n158_856# w_n358_n4193# sky130_fd_pr__pfet_g5v0d10v5 ad=5.8e+11p pd=4.58e+06u as=5.8e+11p ps=4.58e+06u w=2e+06u l=1e+06u
X2 a_100_n1784# a_n100_n3993# a_n158_n1784# w_n358_n4193# sky130_fd_pr__pfet_g5v0d10v5 ad=5.8e+11p pd=4.58e+06u as=5.8e+11p ps=4.58e+06u w=2e+06u l=1e+06u
X3 a_100_n3896# a_n100_n3993# a_n158_n3896# w_n358_n4193# sky130_fd_pr__pfet_g5v0d10v5 ad=5.8e+11p pd=4.58e+06u as=5.8e+11p ps=4.58e+06u w=2e+06u l=1e+06u
X4 a_100_328# a_n100_n3993# a_n158_328# w_n358_n4193# sky130_fd_pr__pfet_g5v0d10v5 ad=5.8e+11p pd=4.58e+06u as=5.8e+11p ps=4.58e+06u w=2e+06u l=1e+06u
X5 a_100_3496# a_n100_n3993# a_n158_3496# w_n358_n4193# sky130_fd_pr__pfet_g5v0d10v5 ad=5.8e+11p pd=4.58e+06u as=5.8e+11p ps=4.58e+06u w=2e+06u l=1e+06u
X6 a_100_1384# a_n100_n3993# a_n158_1384# w_n358_n4193# sky130_fd_pr__pfet_g5v0d10v5 ad=5.8e+11p pd=4.58e+06u as=5.8e+11p ps=4.58e+06u w=2e+06u l=1e+06u
X7 a_100_n1256# a_n100_n3993# a_n158_n1256# w_n358_n4193# sky130_fd_pr__pfet_g5v0d10v5 ad=5.8e+11p pd=4.58e+06u as=5.8e+11p ps=4.58e+06u w=2e+06u l=1e+06u
X8 a_100_n3368# a_n100_n3993# a_n158_n3368# w_n358_n4193# sky130_fd_pr__pfet_g5v0d10v5 ad=5.8e+11p pd=4.58e+06u as=5.8e+11p ps=4.58e+06u w=2e+06u l=1e+06u
X9 a_100_2968# a_n100_n3993# a_n158_2968# w_n358_n4193# sky130_fd_pr__pfet_g5v0d10v5 ad=5.8e+11p pd=4.58e+06u as=5.8e+11p ps=4.58e+06u w=2e+06u l=1e+06u
X10 a_100_n200# a_n100_n3993# a_n158_n200# w_n358_n4193# sky130_fd_pr__pfet_g5v0d10v5 ad=5.8e+11p pd=4.58e+06u as=5.8e+11p ps=4.58e+06u w=2e+06u l=1e+06u
X11 a_100_n2840# a_n100_n3993# a_n158_n2840# w_n358_n4193# sky130_fd_pr__pfet_g5v0d10v5 ad=5.8e+11p pd=4.58e+06u as=5.8e+11p ps=4.58e+06u w=2e+06u l=1e+06u
X12 a_100_2440# a_n100_n3993# a_n158_2440# w_n358_n4193# sky130_fd_pr__pfet_g5v0d10v5 ad=5.8e+11p pd=4.58e+06u as=5.8e+11p ps=4.58e+06u w=2e+06u l=1e+06u
X13 a_100_n2312# a_n100_n3993# a_n158_n2312# w_n358_n4193# sky130_fd_pr__pfet_g5v0d10v5 ad=5.8e+11p pd=4.58e+06u as=5.8e+11p ps=4.58e+06u w=2e+06u l=1e+06u
X14 a_100_1912# a_n100_n3993# a_n158_1912# w_n358_n4193# sky130_fd_pr__pfet_g5v0d10v5 ad=5.8e+11p pd=4.58e+06u as=5.8e+11p ps=4.58e+06u w=2e+06u l=1e+06u
.ends

.subckt sky130_fd_pr__cap_mim_m3_2_GH5TRZ c2_n1666_n1415# m4_n1766_n1515#
X0 c2_n1666_n1415# m4_n1766_n1515# sky130_fd_pr__cap_mim_m3_2 l=1.415e+07u w=1.415e+07u
.ends

.subckt sky130_fd_pr__nfet_g5v0d10v5_FEGU4A a_n158_55# a_100_n255# a_100_55# a_n158_365#
+ a_n158_n255# a_n100_n653# a_100_n565# a_n292_n787# a_100_365# a_n158_n565#
X0 a_100_n565# a_n100_n653# a_n158_n565# a_n292_n787# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=1e+06u
X1 a_100_n255# a_n100_n653# a_n158_n255# a_n292_n787# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=1e+06u
X2 a_100_55# a_n100_n653# a_n158_55# a_n292_n787# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=1e+06u
X3 a_100_365# a_n100_n653# a_n158_365# a_n292_n787# sky130_fd_pr__nfet_g5v0d10v5 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=1e+06u
.ends

.subckt op_amp_layout1 Out Vplus m1_288_3448# Vin2 Vin1 VSUBS
Xsky130_fd_pr__nfet_g5v0d10v5_8PFU4A_0 Out VSUBS Out VSUBS m1_288_3448# Out VSUBS
+ VSUBS sky130_fd_pr__nfet_g5v0d10v5_8PFU4A
Xsky130_fd_pr__pfet_g5v0d10v5_QS9L5N_0 Vplus m1_3440_3940# Vplus Vplus Vplus Vplus
+ m1_3440_3940# m1_3440_3940# m1_3440_3940# m1_3440_3940# sky130_fd_pr__pfet_g5v0d10v5_QS9L5N
Xsky130_fd_pr__pfet_g5v0d10v5_QS9L5N_1 Vplus m1_3440_3940# Vplus Vplus Vplus Vplus
+ m1_n3538_4904# m1_n3538_4904# m1_n3538_4904# m1_n3538_4904# sky130_fd_pr__pfet_g5v0d10v5_QS9L5N
Xsky130_fd_pr__nfet_g5v0d10v5_NQKU4A_0 m1_288_3448# m1_288_3448# VSUBS m1_288_3448#
+ VSUBS VSUBS VSUBS m1_288_3448# m1_288_3448# m1_288_3448# VSUBS m1_288_3448# m1_288_3448#
+ VSUBS VSUBS VSUBS m1_288_3448# VSUBS VSUBS m1_288_3448# sky130_fd_pr__nfet_g5v0d10v5_NQKU4A
Xsky130_fd_pr__pfet_g5v0d10v5_2JCT5W_0 m1_n3538_4904# Vplus Out Out Out Out Out Out
+ Vplus Out Vplus Out Out Out Out Vplus Out Vplus Vplus Vplus Vplus Vplus Vplus Out
+ Vplus Vplus Out Vplus Vplus Out Vplus Vplus sky130_fd_pr__pfet_g5v0d10v5_2JCT5W
Xsky130_fd_pr__cap_mim_m3_2_GH5TRZ_0 Out m1_n3538_4904# sky130_fd_pr__cap_mim_m3_2_GH5TRZ
Xsky130_fd_pr__nfet_g5v0d10v5_FEGU4A_0 VSUBS m1_1768_4254# m1_1768_4254# VSUBS VSUBS
+ m1_288_3448# m1_1768_4254# VSUBS m1_1768_4254# VSUBS sky130_fd_pr__nfet_g5v0d10v5_FEGU4A
Xsky130_fd_pr__nfet_g5v0d10v5_FEGU4A_1 m1_1768_4254# m1_n3538_4904# m1_n3538_4904#
+ m1_1768_4254# m1_1768_4254# Vin2 m1_n3538_4904# VSUBS m1_n3538_4904# m1_1768_4254#
+ sky130_fd_pr__nfet_g5v0d10v5_FEGU4A
Xsky130_fd_pr__nfet_g5v0d10v5_FEGU4A_2 m1_1768_4254# m1_3440_3940# m1_3440_3940# m1_1768_4254#
+ m1_1768_4254# Vin1 m1_3440_3940# VSUBS m1_3440_3940# m1_1768_4254# sky130_fd_pr__nfet_g5v0d10v5_FEGU4A
.ends

.subckt sky130_fd_pr__res_high_po_0p35_V8E24B a_n35_n1646# a_n35_1214# a_n165_n1776#
X0 a_n35_n1646# a_n35_1214# a_n165_n1776# sky130_fd_pr__res_high_po_0p35 l=1.214e+07u
.ends

.subckt sky130_fd_pr__cap_mim_m3_2_3VRXMH c2_n5212_n7200# m4_n5312_n7300#
X0 c2_n5212_n7200# m4_n5312_n7300# sky130_fd_pr__cap_mim_m3_2 l=2.3e+07u w=2.3e+07u
X1 c2_n5212_n7200# m4_n5312_n7300# sky130_fd_pr__cap_mim_m3_2 l=2.3e+07u w=2.3e+07u
X2 c2_n5212_n7200# m4_n5312_n7300# sky130_fd_pr__cap_mim_m3_2 l=2.3e+07u w=2.3e+07u
X3 c2_n5212_n7200# m4_n5312_n7300# sky130_fd_pr__cap_mim_m3_2 l=2.3e+07u w=2.3e+07u
X4 c2_n5212_n7200# m4_n5312_n7300# sky130_fd_pr__cap_mim_m3_2 l=2.3e+07u w=2.3e+07u
X5 c2_n5212_n7200# m4_n5312_n7300# sky130_fd_pr__cap_mim_m3_2 l=2.3e+07u w=2.3e+07u
.ends

.subckt sky130_fd_pr__cap_mim_m3_1_3VRXMH m3_n4909_n7300# sky130_fd_pr__cap_mim_m3_2_3VRXMH_0/c2_n5212_n7200#
+ c1_n4809_n7200#
Xsky130_fd_pr__cap_mim_m3_2_3VRXMH_0 sky130_fd_pr__cap_mim_m3_2_3VRXMH_0/c2_n5212_n7200#
+ c1_n4809_n7200# sky130_fd_pr__cap_mim_m3_2_3VRXMH
X0 c1_n4809_n7200# m3_n4909_n7300# sky130_fd_pr__cap_mim_m3_1 l=2.3e+07u w=2.3e+07u
X1 c1_n4809_n7200# m3_n4909_n7300# sky130_fd_pr__cap_mim_m3_1 l=2.3e+07u w=2.3e+07u
X2 c1_n4809_n7200# m3_n4909_n7300# sky130_fd_pr__cap_mim_m3_1 l=2.3e+07u w=2.3e+07u
X3 c1_n4809_n7200# m3_n4909_n7300# sky130_fd_pr__cap_mim_m3_1 l=2.3e+07u w=2.3e+07u
X4 c1_n4809_n7200# m3_n4909_n7300# sky130_fd_pr__cap_mim_m3_1 l=2.3e+07u w=2.3e+07u
X5 c1_n4809_n7200# m3_n4909_n7300# sky130_fd_pr__cap_mim_m3_1 l=2.3e+07u w=2.3e+07u
.ends

.subckt sky130_fd_pr__pfet_g5v0d10v5_WEH7DU a_n50_n4097# a_50_n4000# w_n308_n4297#
+ a_n108_n4000#
X0 a_50_n4000# a_n50_n4097# a_n108_n4000# w_n308_n4297# sky130_fd_pr__pfet_g5v0d10v5 ad=1.16e+13p pd=8.058e+07u as=1.16e+13p ps=8.058e+07u w=4e+07u l=500000u
.ends

.subckt pass_element li_1954_12108# m1_2222_11902# m1_2118_19948#
Xsky130_fd_pr__pfet_g5v0d10v5_WEH7DU_16 m1_2118_19948# m1_2222_11902# li_1954_12108#
+ li_1954_12108# sky130_fd_pr__pfet_g5v0d10v5_WEH7DU
Xsky130_fd_pr__pfet_g5v0d10v5_WEH7DU_6 m1_2118_19948# m1_2222_11902# li_1954_12108#
+ li_1954_12108# sky130_fd_pr__pfet_g5v0d10v5_WEH7DU
Xsky130_fd_pr__pfet_g5v0d10v5_WEH7DU_17 m1_2118_19948# m1_2222_11902# li_1954_12108#
+ li_1954_12108# sky130_fd_pr__pfet_g5v0d10v5_WEH7DU
Xsky130_fd_pr__pfet_g5v0d10v5_WEH7DU_7 m1_2118_19948# m1_2222_11902# li_1954_12108#
+ li_1954_12108# sky130_fd_pr__pfet_g5v0d10v5_WEH7DU
Xsky130_fd_pr__pfet_g5v0d10v5_WEH7DU_18 m1_2118_19948# m1_2222_11902# li_1954_12108#
+ li_1954_12108# sky130_fd_pr__pfet_g5v0d10v5_WEH7DU
Xsky130_fd_pr__pfet_g5v0d10v5_WEH7DU_8 m1_2118_19948# m1_2222_11902# li_1954_12108#
+ li_1954_12108# sky130_fd_pr__pfet_g5v0d10v5_WEH7DU
Xsky130_fd_pr__pfet_g5v0d10v5_WEH7DU_19 m1_2118_19948# m1_2222_11902# li_1954_12108#
+ li_1954_12108# sky130_fd_pr__pfet_g5v0d10v5_WEH7DU
Xsky130_fd_pr__pfet_g5v0d10v5_WEH7DU_9 m1_2118_19948# m1_2222_11902# li_1954_12108#
+ li_1954_12108# sky130_fd_pr__pfet_g5v0d10v5_WEH7DU
Xsky130_fd_pr__pfet_g5v0d10v5_WEH7DU_10 m1_2118_19948# m1_2222_11902# li_1954_12108#
+ li_1954_12108# sky130_fd_pr__pfet_g5v0d10v5_WEH7DU
Xsky130_fd_pr__pfet_g5v0d10v5_WEH7DU_0 m1_2118_19948# m1_2222_11902# li_1954_12108#
+ li_1954_12108# sky130_fd_pr__pfet_g5v0d10v5_WEH7DU
Xsky130_fd_pr__pfet_g5v0d10v5_WEH7DU_11 m1_2118_19948# m1_2222_11902# li_1954_12108#
+ li_1954_12108# sky130_fd_pr__pfet_g5v0d10v5_WEH7DU
Xsky130_fd_pr__pfet_g5v0d10v5_WEH7DU_1 m1_2118_19948# m1_2222_11902# li_1954_12108#
+ li_1954_12108# sky130_fd_pr__pfet_g5v0d10v5_WEH7DU
Xsky130_fd_pr__pfet_g5v0d10v5_WEH7DU_12 m1_2118_19948# m1_2222_11902# li_1954_12108#
+ li_1954_12108# sky130_fd_pr__pfet_g5v0d10v5_WEH7DU
Xsky130_fd_pr__pfet_g5v0d10v5_WEH7DU_2 m1_2118_19948# m1_2222_11902# li_1954_12108#
+ li_1954_12108# sky130_fd_pr__pfet_g5v0d10v5_WEH7DU
Xsky130_fd_pr__pfet_g5v0d10v5_WEH7DU_13 m1_2118_19948# m1_2222_11902# li_1954_12108#
+ li_1954_12108# sky130_fd_pr__pfet_g5v0d10v5_WEH7DU
Xsky130_fd_pr__pfet_g5v0d10v5_WEH7DU_4 m1_2118_19948# m1_2222_11902# li_1954_12108#
+ li_1954_12108# sky130_fd_pr__pfet_g5v0d10v5_WEH7DU
Xsky130_fd_pr__pfet_g5v0d10v5_WEH7DU_3 m1_2118_19948# m1_2222_11902# li_1954_12108#
+ li_1954_12108# sky130_fd_pr__pfet_g5v0d10v5_WEH7DU
Xsky130_fd_pr__pfet_g5v0d10v5_WEH7DU_15 m1_2118_19948# m1_2222_11902# li_1954_12108#
+ li_1954_12108# sky130_fd_pr__pfet_g5v0d10v5_WEH7DU
Xsky130_fd_pr__pfet_g5v0d10v5_WEH7DU_14 m1_2118_19948# m1_2222_11902# li_1954_12108#
+ li_1954_12108# sky130_fd_pr__pfet_g5v0d10v5_WEH7DU
Xsky130_fd_pr__pfet_g5v0d10v5_WEH7DU_5 m1_2118_19948# m1_2222_11902# li_1954_12108#
+ li_1954_12108# sky130_fd_pr__pfet_g5v0d10v5_WEH7DU
.ends

.subckt LDO op_amp_layout1_0/Vin1 Vout VSUBS VDD
Xcurrent_source_0 current_source_0/out_current VDD VSUBS current_source
Xsky130_fd_pr__res_high_po_0p35_8W29VJ_0 Vout VSUBS op_amp_layout1_0/Vin2 sky130_fd_pr__res_high_po_0p35_8W29VJ
Xsky130_fd_pr__res_high_po_0p35_8W29VJ_1 op_amp_layout1_0/Out VSUBS m1_4150_2114#
+ sky130_fd_pr__res_high_po_0p35_8W29VJ
Xop_amp_layout1_0 op_amp_layout1_0/Out VDD current_source_0/out_current op_amp_layout1_0/Vin2
+ op_amp_layout1_0/Vin1 VSUBS op_amp_layout1
Xsky130_fd_pr__res_high_po_0p35_V8E24B_0 op_amp_layout1_0/Vin2 VSUBS VSUBS sky130_fd_pr__res_high_po_0p35_V8E24B
Xsky130_fd_pr__cap_mim_m3_1_3VRXMH_0 Vout Vout m1_4150_2114# sky130_fd_pr__cap_mim_m3_1_3VRXMH
Xpass_element_0 VDD Vout op_amp_layout1_0/Out pass_element
.ends

.subckt sky130_fd_pr__pfet_01v8_lvt_E98R26 a_35_n288# a_n163_n385# a_221_n385# a_291_n288#
+ a_n221_n288# a_n35_n385# a_93_n385# a_n349_n288# w_n487_n507# a_163_n288# a_n93_n288#
+ a_n291_n385#
X0 a_163_n288# a_93_n385# a_35_n288# w_n487_n507# sky130_fd_pr__pfet_01v8_lvt ad=8.352e+11p pd=6.34e+06u as=8.352e+11p ps=6.34e+06u w=2.88e+06u l=350000u
X1 a_n93_n288# a_n163_n385# a_n221_n288# w_n487_n507# sky130_fd_pr__pfet_01v8_lvt ad=8.352e+11p pd=6.34e+06u as=8.352e+11p ps=6.34e+06u w=2.88e+06u l=350000u
X2 a_291_n288# a_221_n385# a_163_n288# w_n487_n507# sky130_fd_pr__pfet_01v8_lvt ad=8.352e+11p pd=6.34e+06u as=0p ps=0u w=2.88e+06u l=350000u
X3 a_n221_n288# a_n291_n385# a_n349_n288# w_n487_n507# sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=8.352e+11p ps=6.34e+06u w=2.88e+06u l=350000u
X4 a_35_n288# a_n35_n385# a_n93_n288# w_n487_n507# sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=2.88e+06u l=350000u
.ends

.subckt sky130_fd_pr__nfet_03v3_nvt_QBNVYP a_445_n300# a_n637_n522# a_29_n388# a_n129_n388#
+ a_187_n388# a_n287_n388# a_345_n388# a_n29_n300# a_n187_n300# a_n445_n388# a_n345_n300#
+ a_129_n300# a_n503_n300# a_287_n300#
X0 a_n345_n300# a_n445_n388# a_n503_n300# a_n637_n522# sky130_fd_pr__nfet_03v3_nvt ad=8.7e+11p pd=6.58e+06u as=8.7e+11p ps=6.58e+06u w=3e+06u l=500000u
X1 a_129_n300# a_29_n388# a_n29_n300# a_n637_n522# sky130_fd_pr__nfet_03v3_nvt ad=8.7e+11p pd=6.58e+06u as=8.7e+11p ps=6.58e+06u w=3e+06u l=500000u
X2 a_445_n300# a_345_n388# a_287_n300# a_n637_n522# sky130_fd_pr__nfet_03v3_nvt ad=8.7e+11p pd=6.58e+06u as=8.7e+11p ps=6.58e+06u w=3e+06u l=500000u
X3 a_n29_n300# a_n129_n388# a_n187_n300# a_n637_n522# sky130_fd_pr__nfet_03v3_nvt ad=0p pd=0u as=8.7e+11p ps=6.58e+06u w=3e+06u l=500000u
X4 a_n187_n300# a_n287_n388# a_n345_n300# a_n637_n522# sky130_fd_pr__nfet_03v3_nvt ad=0p pd=0u as=0p ps=0u w=3e+06u l=500000u
X5 a_287_n300# a_187_n388# a_129_n300# a_n637_n522# sky130_fd_pr__nfet_03v3_nvt ad=0p pd=0u as=0p ps=0u w=3e+06u l=500000u
.ends

.subckt sky130_fd_pr__res_xhigh_po_0p35_LSEQGR a_n165_n637# a_n35_n507# a_n35_75#
X0 a_n35_n507# a_n35_75# a_n165_n637# sky130_fd_pr__res_xhigh_po_0p35 l=750000u
.ends

.subckt sky130_fd_pr__pfet_01v8_lvt_ZUTRP2 a_733_n817# a_35_n720# a_349_n817# a_931_n720#
+ a_547_n720# a_n861_n720# a_n35_n817# a_n477_n720# a_93_n817# a_291_n720# a_n547_n817#
+ a_n931_n817# w_n1127_n939# a_n221_n720# a_n989_n720# a_605_n817# a_n291_n817# a_803_n720#
+ a_419_n720# a_n349_n720# a_n733_n720# a_163_n720# a_n419_n817# a_n803_n817# a_861_n817#
+ a_477_n817# a_n93_n720# a_n163_n817# a_675_n720# a_221_n817# a_n605_n720# a_n675_n817#
X0 a_n861_n720# a_n931_n817# a_n989_n720# w_n1127_n939# sky130_fd_pr__pfet_01v8_lvt ad=2.088e+12p pd=1.498e+07u as=2.088e+12p ps=1.498e+07u w=7.2e+06u l=350000u
X1 a_n477_n720# a_n547_n817# a_n605_n720# w_n1127_n939# sky130_fd_pr__pfet_01v8_lvt ad=2.088e+12p pd=1.498e+07u as=2.088e+12p ps=1.498e+07u w=7.2e+06u l=350000u
X2 a_931_n720# a_861_n817# a_803_n720# w_n1127_n939# sky130_fd_pr__pfet_01v8_lvt ad=2.088e+12p pd=1.498e+07u as=2.088e+12p ps=1.498e+07u w=7.2e+06u l=350000u
X3 a_547_n720# a_477_n817# a_419_n720# w_n1127_n939# sky130_fd_pr__pfet_01v8_lvt ad=2.088e+12p pd=1.498e+07u as=2.088e+12p ps=1.498e+07u w=7.2e+06u l=350000u
X4 a_163_n720# a_93_n817# a_35_n720# w_n1127_n939# sky130_fd_pr__pfet_01v8_lvt ad=2.088e+12p pd=1.498e+07u as=2.088e+12p ps=1.498e+07u w=7.2e+06u l=350000u
X5 a_675_n720# a_605_n817# a_547_n720# w_n1127_n939# sky130_fd_pr__pfet_01v8_lvt ad=2.088e+12p pd=1.498e+07u as=0p ps=0u w=7.2e+06u l=350000u
X6 a_n605_n720# a_n675_n817# a_n733_n720# w_n1127_n939# sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=2.088e+12p ps=1.498e+07u w=7.2e+06u l=350000u
X7 a_n93_n720# a_n163_n817# a_n221_n720# w_n1127_n939# sky130_fd_pr__pfet_01v8_lvt ad=2.088e+12p pd=1.498e+07u as=2.088e+12p ps=1.498e+07u w=7.2e+06u l=350000u
X8 a_n733_n720# a_n803_n817# a_n861_n720# w_n1127_n939# sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=7.2e+06u l=350000u
X9 a_n349_n720# a_n419_n817# a_n477_n720# w_n1127_n939# sky130_fd_pr__pfet_01v8_lvt ad=2.088e+12p pd=1.498e+07u as=0p ps=0u w=7.2e+06u l=350000u
X10 a_291_n720# a_221_n817# a_163_n720# w_n1127_n939# sky130_fd_pr__pfet_01v8_lvt ad=2.088e+12p pd=1.498e+07u as=0p ps=0u w=7.2e+06u l=350000u
X11 a_803_n720# a_733_n817# a_675_n720# w_n1127_n939# sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=7.2e+06u l=350000u
X12 a_n221_n720# a_n291_n817# a_n349_n720# w_n1127_n939# sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=7.2e+06u l=350000u
X13 a_419_n720# a_349_n817# a_291_n720# w_n1127_n939# sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=7.2e+06u l=350000u
X14 a_35_n720# a_n35_n817# a_n93_n720# w_n1127_n939# sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=7.2e+06u l=350000u
.ends

.subckt opamp_big Inv NonInv Vdd Out Vss
Xsky130_fd_pr__cap_mim_m3_1_6ZNTNB_0 Out m1_1444_62# sky130_fd_pr__cap_mim_m3_1_6ZNTNB
Xsky130_fd_pr__pfet_01v8_lvt_E98R26_0 m1_n108_1038# m1_n108_1038# m1_n108_1038# m1_n108_1038#
+ m1_n108_1038# m1_n108_1038# m1_n108_1038# Vdd Vdd Vdd Vdd m1_n108_1038# sky130_fd_pr__pfet_01v8_lvt_E98R26
Xsky130_fd_pr__pfet_01v8_lvt_E98R26_1 m1_1444_62# m1_n108_1038# m1_n108_1038# m1_1444_62#
+ m1_1444_62# m1_n108_1038# m1_n108_1038# Vdd Vdd Vdd Vdd m1_n108_1038# sky130_fd_pr__pfet_01v8_lvt_E98R26
Xsky130_fd_pr__nfet_01v8_lvt_46VND8_0 Vss Vss li_318_n684# Vss li_318_n684# Out li_318_n684#
+ Out li_318_n684# Out Vss li_318_n684# sky130_fd_pr__nfet_01v8_lvt_46VND8
Xsky130_fd_pr__nfet_03v3_nvt_QBNVYP_0 m1_n108_1038# Vss Inv Inv Inv Inv Inv m1_256_62#
+ m1_n108_1038# Inv m1_256_62# m1_n108_1038# m1_n108_1038# m1_256_62# sky130_fd_pr__nfet_03v3_nvt_QBNVYP
Xsky130_fd_pr__nfet_01v8_lvt_595QY5_0 li_318_n684# Vss Vss li_318_n684# Vss Vss li_318_n684#
+ li_318_n684# li_318_n684# li_318_n684# li_318_n684# li_318_n684# sky130_fd_pr__nfet_01v8_lvt_595QY5
Xsky130_fd_pr__nfet_03v3_nvt_QBNVYP_1 m1_1444_62# Vss NonInv NonInv NonInv NonInv
+ NonInv m1_256_62# m1_1444_62# NonInv m1_256_62# m1_1444_62# m1_1444_62# m1_256_62#
+ sky130_fd_pr__nfet_03v3_nvt_QBNVYP
Xsky130_fd_pr__nfet_01v8_lvt_595QY5_1 li_318_n684# Vss Vss li_318_n684# Vss Vss m1_256_62#
+ li_318_n684# li_318_n684# m1_256_62# li_318_n684# m1_256_62# sky130_fd_pr__nfet_01v8_lvt_595QY5
Xsky130_fd_pr__res_xhigh_po_0p35_LSEQGR_0 Vss li_318_n684# Vdd sky130_fd_pr__res_xhigh_po_0p35_LSEQGR
Xsky130_fd_pr__pfet_01v8_lvt_ZUTRP2_0 m1_1444_62# Out m1_1444_62# Vdd Out Vdd m1_1444_62#
+ Out m1_1444_62# Out m1_1444_62# m1_1444_62# Vdd Out Out m1_1444_62# m1_1444_62#
+ Out Vdd Vdd Out Vdd m1_1444_62# m1_1444_62# m1_1444_62# m1_1444_62# Vdd m1_1444_62#
+ Vdd m1_1444_62# Vdd m1_1444_62# sky130_fd_pr__pfet_01v8_lvt_ZUTRP2
Xsky130_fd_pr__cap_mim_m3_2_6ZNTNB_0 Out m1_1444_62# sky130_fd_pr__cap_mim_m3_2_6ZNTNB
.ends

.subckt sky130_fd_pr__res_xhigh_po_0p35_GYHWU2 a_n165_n637# a_n35_n507# a_n35_75#
X0 a_n35_n507# a_n35_75# a_n165_n637# sky130_fd_pr__res_xhigh_po_0p35 l=750000u
.ends

.subckt sky130_fd_pr__res_xhigh_po_0p35_X9YLXN a_n35_111# a_n165_n673# a_n35_n543#
X0 a_n35_n543# a_n35_111# a_n165_n673# sky130_fd_pr__res_xhigh_po_0p35 l=1.11e+06u
.ends

.subckt sky130_fd_pr__diode_pd2nw_11v0_N4GF4K a_198_198# a_n1198_198# a_198_2990#
+ a_198_n3990# a_198_1594# a_n1198_2990# a_198_4386# a_198_n2594# a_198_n5386# a_n1198_1594#
+ a_198_n1198# a_n1198_4386# a_n1198_n3990# w_n1396_n5584# a_n1198_n2594# a_n1198_n5386#
+ a_n1198_n1198#
D0 a_198_4386# w_n1396_n5584# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D1 a_n1198_198# w_n1396_n5584# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D2 a_n1198_n5386# w_n1396_n5584# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D3 a_198_198# w_n1396_n5584# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D4 a_n1198_n1198# w_n1396_n5584# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D5 a_n1198_1594# w_n1396_n5584# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D6 a_198_n2594# w_n1396_n5584# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D7 a_198_n3990# w_n1396_n5584# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D8 a_198_1594# w_n1396_n5584# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D9 a_n1198_n2594# w_n1396_n5584# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D10 a_n1198_2990# w_n1396_n5584# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D11 a_n1198_n3990# w_n1396_n5584# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D12 a_198_n5386# w_n1396_n5584# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D13 a_n1198_4386# w_n1396_n5584# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D14 a_198_2990# w_n1396_n5584# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
D15 a_198_n1198# w_n1396_n5584# sky130_fd_pr__diode_pd2nw_11v0 pj=2e+07u area=2.5e+13p
.ends

.subckt sky130_fd_pr__res_xhigh_po_1p41_YC7ZJC a_n141_n554# a_n271_n684# a_n141_122#
X0 a_n141_n554# a_n141_122# a_n271_n684# sky130_fd_pr__res_xhigh_po_1p41 l=1.22e+06u
.ends

.subckt sky130_fd_pr__cap_mim_m3_2_EZNXMG c2_n2251_n1000# m4_n2351_n1100#
X0 c2_n2251_n1000# m4_n2351_n1100# sky130_fd_pr__cap_mim_m3_2 l=1e+07u w=2e+07u
.ends

.subckt sky130_fd_pr__cap_mim_m3_1_EZNXMG m3_n2150_n1100# c1_n2050_n1000#
X0 c1_n2050_n1000# m3_n2150_n1100# sky130_fd_pr__cap_mim_m3_1 l=1e+07u w=2e+07u
.ends

.subckt pwm_lower VSUBS m1_15841_7108# opamp_big_0/Vdd opamp_small_1/Inv li_15521_6884#
Xopamp_big_0 opamp_big_0/Inv opamp_big_0/NonInv opamp_big_0/Vdd opamp_big_0/Out VSUBS
+ opamp_big
Xsky130_fd_pr__res_xhigh_po_0p35_GYHWU2_0 VSUBS opamp_small_0/Inv opamp_small_1/Out
+ sky130_fd_pr__res_xhigh_po_0p35_GYHWU2
Xsky130_fd_pr__res_xhigh_po_0p35_GYHWU2_1 VSUBS opamp_small_1/NonInv opamp_small_1/Out
+ sky130_fd_pr__res_xhigh_po_0p35_GYHWU2
Xsky130_fd_pr__res_xhigh_po_0p35_X9YLXN_0 VSUBS VSUBS opamp_big_0/NonInv sky130_fd_pr__res_xhigh_po_0p35_X9YLXN
Xsky130_fd_pr__res_xhigh_po_0p35_X9YLXN_1 li_15521_6884# VSUBS opamp_big_0/NonInv
+ sky130_fd_pr__res_xhigh_po_0p35_X9YLXN
Xsky130_fd_pr__diode_pd2nw_11v0_N4GF4K_0 m1_15841_7108# m1_15841_7108# m1_15841_7108#
+ m1_15841_7108# m1_15841_7108# m1_15841_7108# m1_15841_7108# m1_15841_7108# m1_15841_7108#
+ m1_15841_7108# m1_15841_7108# m1_15841_7108# m1_15841_7108# li_15521_6884# m1_15841_7108#
+ m1_15841_7108# m1_15841_7108# sky130_fd_pr__diode_pd2nw_11v0_N4GF4K
Xsky130_fd_pr__res_xhigh_po_1p41_YC7ZJC_0 opamp_big_0/Inv VSUBS opamp_small_1/NonInv
+ sky130_fd_pr__res_xhigh_po_1p41_YC7ZJC
Xsky130_fd_pr__cap_mim_m3_2_EZNXMG_0 opamp_small_0/Inv opamp_big_0/Inv sky130_fd_pr__cap_mim_m3_2_EZNXMG
Xlarge_nmos_g5d10_0 m1_15841_7108# m1_15841_7108# m1_15841_7108# m1_15841_7108# m1_15841_7108#
+ m1_15841_7108# m1_15841_7108# m1_15841_7108# m1_15841_7108# m1_15841_7108# m1_15841_7108#
+ m1_15841_7108# m1_15841_7108# m1_15841_7108# m1_15841_7108# m1_15841_7108# m1_15841_7108#
+ m1_15841_7108# m1_15841_7108# opamp_big_0/Out m1_15841_7108# m1_15841_7108# m1_15841_7108#
+ m1_15841_7108# m1_15841_7108# m1_15841_7108# m1_15841_7108# m1_15841_7108# m1_15841_7108#
+ m1_15841_7108# m1_15841_7108# m1_15841_7108# m1_15841_7108# m1_15841_7108# m1_15841_7108#
+ m1_15841_7108# m1_15841_7108# m1_15841_7108# m1_15841_7108# m1_15841_7108# m1_15841_7108#
+ m1_15841_7108# VSUBS large_nmos_g5d10
Xlarge_nmos_g5d10_1 m1_15841_7108# m1_15841_7108# m1_15841_7108# m1_15841_7108# m1_15841_7108#
+ m1_15841_7108# m1_15841_7108# m1_15841_7108# m1_15841_7108# m1_15841_7108# m1_15841_7108#
+ m1_15841_7108# m1_15841_7108# m1_15841_7108# m1_15841_7108# m1_15841_7108# m1_15841_7108#
+ m1_15841_7108# m1_15841_7108# opamp_big_0/Out m1_15841_7108# m1_15841_7108# m1_15841_7108#
+ m1_15841_7108# m1_15841_7108# m1_15841_7108# m1_15841_7108# m1_15841_7108# m1_15841_7108#
+ m1_15841_7108# m1_15841_7108# m1_15841_7108# m1_15841_7108# m1_15841_7108# m1_15841_7108#
+ m1_15841_7108# m1_15841_7108# m1_15841_7108# m1_15841_7108# m1_15841_7108# m1_15841_7108#
+ m1_15841_7108# VSUBS large_nmos_g5d10
Xopamp_small_0 opamp_small_0/Inv opamp_small_1/Inv opamp_big_0/Vdd opamp_big_0/Inv
+ VSUBS opamp_small
Xopamp_small_1 opamp_small_1/Inv opamp_small_1/NonInv opamp_big_0/Vdd opamp_small_1/Out
+ VSUBS opamp_small
Xsky130_fd_pr__cap_mim_m3_1_EZNXMG_0 opamp_small_0/Inv opamp_big_0/Inv sky130_fd_pr__cap_mim_m3_1_EZNXMG
.ends

.subckt sky130_fd_pr__diode_pd2nw_11v0_K4SERG a_n45_n45# w_n243_n243#
D0 a_n45_n45# w_n243_n243# sky130_fd_pr__diode_pd2nw_11v0 pj=1.8e+06u area=2.025e+11p
.ends

.subckt sky130_fd_pr__nfet_g5v0d10v5_9KQQSQ a_n2308_n2222# a_n2116_n2088#
X0 a_n2308_n2222# a_n2116_n2088# a_n2308_n2222# a_n2308_n2222# sky130_fd_pr__nfet_g5v0d10v5 ad=3.48e+13p pd=2.4348e+08u as=0p ps=0u w=2e+07u l=4e+06u
X1 a_n2308_n2222# a_n2116_n2088# a_n2308_n2222# a_n2308_n2222# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=2e+07u l=4e+06u
X2 a_n2308_n2222# a_n2116_n2088# a_n2308_n2222# a_n2308_n2222# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=2e+07u l=4e+06u
X3 a_n2308_n2222# a_n2116_n2088# a_n2308_n2222# a_n2308_n2222# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=2e+07u l=4e+06u
X4 a_n2308_n2222# a_n2116_n2088# a_n2308_n2222# a_n2308_n2222# sky130_fd_pr__nfet_g5v0d10v5 ad=0p pd=0u as=0p ps=0u w=2e+07u l=4e+06u
.ends

.subckt sky130_fd_pr__cap_mim_m3_2_U59KTN c2_n3251_n100650# m4_n3401_n97810#
X0 c2_n3251_n100650# m4_n3401_n97810# sky130_fd_pr__cap_mim_m3_2 l=3e+07u w=3e+07u
X1 c2_n3251_n100650# m4_n3401_n97810# sky130_fd_pr__cap_mim_m3_2 l=3e+07u w=3e+07u
X2 c2_n3251_n100650# m4_n3401_n97810# sky130_fd_pr__cap_mim_m3_2 l=3e+07u w=3e+07u
X3 c2_n3251_n100650# m4_n3401_n97810# sky130_fd_pr__cap_mim_m3_2 l=3e+07u w=3e+07u
X4 c2_n3251_n100650# m4_n3401_n97810# sky130_fd_pr__cap_mim_m3_2 l=3e+07u w=3e+07u
X5 c2_n3251_n100650# m4_n3401_n97810# sky130_fd_pr__cap_mim_m3_2 l=3e+07u w=3e+07u
X6 c2_n3251_n100650# m4_n3401_n97810# sky130_fd_pr__cap_mim_m3_2 l=3e+07u w=3e+07u
X7 c2_n3251_n100650# m4_n3401_n97810# sky130_fd_pr__cap_mim_m3_2 l=3e+07u w=3e+07u
X8 c2_n3251_n100650# m4_n3401_n97810# sky130_fd_pr__cap_mim_m3_2 l=3e+07u w=3e+07u
X9 c2_n3251_n100650# m4_n3401_n97810# sky130_fd_pr__cap_mim_m3_2 l=3e+07u w=3e+07u
X10 c2_n3251_n100650# m4_n3401_n97810# sky130_fd_pr__cap_mim_m3_2 l=3e+07u w=3e+07u
X11 c2_n3251_n100650# m4_n3401_n97810# sky130_fd_pr__cap_mim_m3_2 l=3e+07u w=3e+07u
X12 c2_n3251_n100650# m4_n3401_n97810# sky130_fd_pr__cap_mim_m3_2 l=3e+07u w=3e+07u
X13 c2_n3251_n100650# m4_n3401_n97810# sky130_fd_pr__cap_mim_m3_2 l=3e+07u w=3e+07u
X14 c2_n3251_n100650# m4_n3401_n97810# sky130_fd_pr__cap_mim_m3_2 l=3e+07u w=3e+07u
X15 c2_n3251_n100650# m4_n3401_n97810# sky130_fd_pr__cap_mim_m3_2 l=3e+07u w=3e+07u
X16 c2_n3251_n100650# m4_n3401_n97810# sky130_fd_pr__cap_mim_m3_2 l=3e+07u w=3e+07u
X17 c2_n3251_n100650# m4_n3401_n97810# sky130_fd_pr__cap_mim_m3_2 l=3e+07u w=3e+07u
X18 c2_n3251_n100650# m4_n3401_n97810# sky130_fd_pr__cap_mim_m3_2 l=3e+07u w=3e+07u
X19 c2_n3251_n100650# m4_n3401_n97810# sky130_fd_pr__cap_mim_m3_2 l=3e+07u w=3e+07u
X20 c2_n3251_n100650# m4_n3401_n97810# sky130_fd_pr__cap_mim_m3_2 l=3e+07u w=3e+07u
X21 c2_n3251_n100650# m4_n3401_n97810# sky130_fd_pr__cap_mim_m3_2 l=3e+07u w=3e+07u
X22 c2_n3251_n100650# m4_n3401_n97810# sky130_fd_pr__cap_mim_m3_2 l=3e+07u w=3e+07u
X23 c2_n3251_n100650# m4_n3401_n97810# sky130_fd_pr__cap_mim_m3_2 l=3e+07u w=3e+07u
X24 c2_n3251_n100650# m4_n3401_n97810# sky130_fd_pr__cap_mim_m3_2 l=3e+07u w=3e+07u
X25 c2_n3251_n100650# m4_n3401_n97810# sky130_fd_pr__cap_mim_m3_2 l=3e+07u w=3e+07u
X26 c2_n3251_n100650# m4_n3401_n97810# sky130_fd_pr__cap_mim_m3_2 l=3e+07u w=3e+07u
X27 c2_n3251_n100650# m4_n3401_n97810# sky130_fd_pr__cap_mim_m3_2 l=3e+07u w=3e+07u
X28 c2_n3251_n100650# m4_n3401_n97810# sky130_fd_pr__cap_mim_m3_2 l=3e+07u w=3e+07u
X29 c2_n3251_n100650# m4_n3401_n97810# sky130_fd_pr__cap_mim_m3_2 l=3e+07u w=3e+07u
X30 c2_n3251_n100650# m4_n3401_n97810# sky130_fd_pr__cap_mim_m3_2 l=3e+07u w=3e+07u
X31 c2_n3251_n100650# m4_n3401_n97810# sky130_fd_pr__cap_mim_m3_2 l=3e+07u w=3e+07u
.ends

.subckt sky130_fd_pr__cap_mim_m3_1_U59KTN c1_n3050_n100650# m3_n3200_n97702#
X0 c1_n3050_n100650# m3_n3200_n97702# sky130_fd_pr__cap_mim_m3_1 l=3e+07u w=3e+07u
X1 c1_n3050_n100650# m3_n3200_n97702# sky130_fd_pr__cap_mim_m3_1 l=3e+07u w=3e+07u
X2 c1_n3050_n100650# m3_n3200_n97702# sky130_fd_pr__cap_mim_m3_1 l=3e+07u w=3e+07u
X3 c1_n3050_n100650# m3_n3200_n97702# sky130_fd_pr__cap_mim_m3_1 l=3e+07u w=3e+07u
X4 c1_n3050_n100650# m3_n3200_n97702# sky130_fd_pr__cap_mim_m3_1 l=3e+07u w=3e+07u
X5 c1_n3050_n100650# m3_n3200_n97702# sky130_fd_pr__cap_mim_m3_1 l=3e+07u w=3e+07u
X6 c1_n3050_n100650# m3_n3200_n97702# sky130_fd_pr__cap_mim_m3_1 l=3e+07u w=3e+07u
X7 c1_n3050_n100650# m3_n3200_n97702# sky130_fd_pr__cap_mim_m3_1 l=3e+07u w=3e+07u
X8 c1_n3050_n100650# m3_n3200_n97702# sky130_fd_pr__cap_mim_m3_1 l=3e+07u w=3e+07u
X9 c1_n3050_n100650# m3_n3200_n97702# sky130_fd_pr__cap_mim_m3_1 l=3e+07u w=3e+07u
X10 c1_n3050_n100650# m3_n3200_n97702# sky130_fd_pr__cap_mim_m3_1 l=3e+07u w=3e+07u
X11 c1_n3050_n100650# m3_n3200_n97702# sky130_fd_pr__cap_mim_m3_1 l=3e+07u w=3e+07u
X12 c1_n3050_n100650# m3_n3200_n97702# sky130_fd_pr__cap_mim_m3_1 l=3e+07u w=3e+07u
X13 c1_n3050_n100650# m3_n3200_n97702# sky130_fd_pr__cap_mim_m3_1 l=3e+07u w=3e+07u
X14 c1_n3050_n100650# m3_n3200_n97702# sky130_fd_pr__cap_mim_m3_1 l=3e+07u w=3e+07u
X15 c1_n3050_n100650# m3_n3200_n97702# sky130_fd_pr__cap_mim_m3_1 l=3e+07u w=3e+07u
X16 c1_n3050_n100650# m3_n3200_n97702# sky130_fd_pr__cap_mim_m3_1 l=3e+07u w=3e+07u
X17 c1_n3050_n100650# m3_n3200_n97702# sky130_fd_pr__cap_mim_m3_1 l=3e+07u w=3e+07u
X18 c1_n3050_n100650# m3_n3200_n97702# sky130_fd_pr__cap_mim_m3_1 l=3e+07u w=3e+07u
X19 c1_n3050_n100650# m3_n3200_n97702# sky130_fd_pr__cap_mim_m3_1 l=3e+07u w=3e+07u
X20 c1_n3050_n100650# m3_n3200_n97702# sky130_fd_pr__cap_mim_m3_1 l=3e+07u w=3e+07u
X21 c1_n3050_n100650# m3_n3200_n97702# sky130_fd_pr__cap_mim_m3_1 l=3e+07u w=3e+07u
X22 c1_n3050_n100650# m3_n3200_n97702# sky130_fd_pr__cap_mim_m3_1 l=3e+07u w=3e+07u
X23 c1_n3050_n100650# m3_n3200_n97702# sky130_fd_pr__cap_mim_m3_1 l=3e+07u w=3e+07u
X24 c1_n3050_n100650# m3_n3200_n97702# sky130_fd_pr__cap_mim_m3_1 l=3e+07u w=3e+07u
X25 c1_n3050_n100650# m3_n3200_n97702# sky130_fd_pr__cap_mim_m3_1 l=3e+07u w=3e+07u
X26 c1_n3050_n100650# m3_n3200_n97702# sky130_fd_pr__cap_mim_m3_1 l=3e+07u w=3e+07u
X27 c1_n3050_n100650# m3_n3200_n97702# sky130_fd_pr__cap_mim_m3_1 l=3e+07u w=3e+07u
X28 c1_n3050_n100650# m3_n3200_n97702# sky130_fd_pr__cap_mim_m3_1 l=3e+07u w=3e+07u
X29 c1_n3050_n100650# m3_n3200_n97702# sky130_fd_pr__cap_mim_m3_1 l=3e+07u w=3e+07u
X30 c1_n3050_n100650# m3_n3200_n97702# sky130_fd_pr__cap_mim_m3_1 l=3e+07u w=3e+07u
X31 c1_n3050_n100650# m3_n3200_n97702# sky130_fd_pr__cap_mim_m3_1 l=3e+07u w=3e+07u
.ends

.subckt decoupling_cell_single_column m2_894_n195476# VSUBS
Xsky130_fd_pr__nfet_g5v0d10v5_9KQQSQ_0 VSUBS m2_894_n195476# sky130_fd_pr__nfet_g5v0d10v5_9KQQSQ
Xsky130_fd_pr__nfet_g5v0d10v5_9KQQSQ_1 VSUBS m2_894_n195476# sky130_fd_pr__nfet_g5v0d10v5_9KQQSQ
Xsky130_fd_pr__nfet_g5v0d10v5_9KQQSQ_2 VSUBS m2_894_n195476# sky130_fd_pr__nfet_g5v0d10v5_9KQQSQ
Xsky130_fd_pr__nfet_g5v0d10v5_9KQQSQ_3 VSUBS m2_894_n195476# sky130_fd_pr__nfet_g5v0d10v5_9KQQSQ
Xsky130_fd_pr__nfet_g5v0d10v5_9KQQSQ_30 VSUBS m2_894_n195476# sky130_fd_pr__nfet_g5v0d10v5_9KQQSQ
Xsky130_fd_pr__nfet_g5v0d10v5_9KQQSQ_4 VSUBS m2_894_n195476# sky130_fd_pr__nfet_g5v0d10v5_9KQQSQ
Xsky130_fd_pr__nfet_g5v0d10v5_9KQQSQ_20 VSUBS m2_894_n195476# sky130_fd_pr__nfet_g5v0d10v5_9KQQSQ
Xsky130_fd_pr__nfet_g5v0d10v5_9KQQSQ_31 VSUBS m2_894_n195476# sky130_fd_pr__nfet_g5v0d10v5_9KQQSQ
Xsky130_fd_pr__nfet_g5v0d10v5_9KQQSQ_5 VSUBS m2_894_n195476# sky130_fd_pr__nfet_g5v0d10v5_9KQQSQ
Xsky130_fd_pr__nfet_g5v0d10v5_9KQQSQ_10 VSUBS m2_894_n195476# sky130_fd_pr__nfet_g5v0d10v5_9KQQSQ
Xsky130_fd_pr__nfet_g5v0d10v5_9KQQSQ_21 VSUBS m2_894_n195476# sky130_fd_pr__nfet_g5v0d10v5_9KQQSQ
Xsky130_fd_pr__nfet_g5v0d10v5_9KQQSQ_6 VSUBS m2_894_n195476# sky130_fd_pr__nfet_g5v0d10v5_9KQQSQ
Xsky130_fd_pr__nfet_g5v0d10v5_9KQQSQ_11 VSUBS m2_894_n195476# sky130_fd_pr__nfet_g5v0d10v5_9KQQSQ
Xsky130_fd_pr__nfet_g5v0d10v5_9KQQSQ_22 VSUBS m2_894_n195476# sky130_fd_pr__nfet_g5v0d10v5_9KQQSQ
Xsky130_fd_pr__nfet_g5v0d10v5_9KQQSQ_7 VSUBS m2_894_n195476# sky130_fd_pr__nfet_g5v0d10v5_9KQQSQ
Xsky130_fd_pr__nfet_g5v0d10v5_9KQQSQ_12 VSUBS m2_894_n195476# sky130_fd_pr__nfet_g5v0d10v5_9KQQSQ
Xsky130_fd_pr__nfet_g5v0d10v5_9KQQSQ_23 VSUBS m2_894_n195476# sky130_fd_pr__nfet_g5v0d10v5_9KQQSQ
Xsky130_fd_pr__nfet_g5v0d10v5_9KQQSQ_8 VSUBS m2_894_n195476# sky130_fd_pr__nfet_g5v0d10v5_9KQQSQ
Xsky130_fd_pr__nfet_g5v0d10v5_9KQQSQ_13 VSUBS m2_894_n195476# sky130_fd_pr__nfet_g5v0d10v5_9KQQSQ
Xsky130_fd_pr__nfet_g5v0d10v5_9KQQSQ_24 VSUBS m2_894_n195476# sky130_fd_pr__nfet_g5v0d10v5_9KQQSQ
Xsky130_fd_pr__nfet_g5v0d10v5_9KQQSQ_9 VSUBS m2_894_n195476# sky130_fd_pr__nfet_g5v0d10v5_9KQQSQ
Xsky130_fd_pr__nfet_g5v0d10v5_9KQQSQ_14 VSUBS m2_894_n195476# sky130_fd_pr__nfet_g5v0d10v5_9KQQSQ
Xsky130_fd_pr__nfet_g5v0d10v5_9KQQSQ_25 VSUBS m2_894_n195476# sky130_fd_pr__nfet_g5v0d10v5_9KQQSQ
Xsky130_fd_pr__nfet_g5v0d10v5_9KQQSQ_15 VSUBS m2_894_n195476# sky130_fd_pr__nfet_g5v0d10v5_9KQQSQ
Xsky130_fd_pr__nfet_g5v0d10v5_9KQQSQ_26 VSUBS m2_894_n195476# sky130_fd_pr__nfet_g5v0d10v5_9KQQSQ
Xsky130_fd_pr__nfet_g5v0d10v5_9KQQSQ_16 VSUBS m2_894_n195476# sky130_fd_pr__nfet_g5v0d10v5_9KQQSQ
Xsky130_fd_pr__nfet_g5v0d10v5_9KQQSQ_17 VSUBS m2_894_n195476# sky130_fd_pr__nfet_g5v0d10v5_9KQQSQ
Xsky130_fd_pr__nfet_g5v0d10v5_9KQQSQ_27 VSUBS m2_894_n195476# sky130_fd_pr__nfet_g5v0d10v5_9KQQSQ
Xsky130_fd_pr__nfet_g5v0d10v5_9KQQSQ_28 VSUBS m2_894_n195476# sky130_fd_pr__nfet_g5v0d10v5_9KQQSQ
Xsky130_fd_pr__nfet_g5v0d10v5_9KQQSQ_18 VSUBS m2_894_n195476# sky130_fd_pr__nfet_g5v0d10v5_9KQQSQ
Xsky130_fd_pr__nfet_g5v0d10v5_9KQQSQ_29 VSUBS m2_894_n195476# sky130_fd_pr__nfet_g5v0d10v5_9KQQSQ
Xsky130_fd_pr__cap_mim_m3_2_U59KTN_0 m2_894_n195476# VSUBS sky130_fd_pr__cap_mim_m3_2_U59KTN
Xsky130_fd_pr__nfet_g5v0d10v5_9KQQSQ_19 VSUBS m2_894_n195476# sky130_fd_pr__nfet_g5v0d10v5_9KQQSQ
Xsky130_fd_pr__cap_mim_m3_1_U59KTN_0 VSUBS m2_894_n195476# sky130_fd_pr__cap_mim_m3_1_U59KTN
.ends

.subckt decoupling_cell VSUBS Vout
Xdecoupling_cell_single_column_29 Vout VSUBS decoupling_cell_single_column
Xdecoupling_cell_single_column_28 Vout VSUBS decoupling_cell_single_column
Xdecoupling_cell_single_column_18 Vout VSUBS decoupling_cell_single_column
Xdecoupling_cell_single_column_17 Vout VSUBS decoupling_cell_single_column
Xdecoupling_cell_single_column_19 Vout VSUBS decoupling_cell_single_column
Xdecoupling_cell_single_column_1 Vout VSUBS decoupling_cell_single_column
Xdecoupling_cell_single_column_0 Vout VSUBS decoupling_cell_single_column
Xdecoupling_cell_single_column_2 Vout VSUBS decoupling_cell_single_column
Xdecoupling_cell_single_column_3 Vout VSUBS decoupling_cell_single_column
Xdecoupling_cell_single_column_4 Vout VSUBS decoupling_cell_single_column
Xdecoupling_cell_single_column_5 Vout VSUBS decoupling_cell_single_column
Xdecoupling_cell_single_column_6 Vout VSUBS decoupling_cell_single_column
Xdecoupling_cell_single_column_7 Vout VSUBS decoupling_cell_single_column
Xdecoupling_cell_single_column_9 Vout VSUBS decoupling_cell_single_column
Xdecoupling_cell_single_column_8 Vout VSUBS decoupling_cell_single_column
Xdecoupling_cell_single_column_31 Vout VSUBS decoupling_cell_single_column
Xdecoupling_cell_single_column_30 Vout VSUBS decoupling_cell_single_column
Xdecoupling_cell_single_column_20 Vout VSUBS decoupling_cell_single_column
Xdecoupling_cell_single_column_21 Vout VSUBS decoupling_cell_single_column
Xdecoupling_cell_single_column_10 Vout VSUBS decoupling_cell_single_column
Xdecoupling_cell_single_column_22 Vout VSUBS decoupling_cell_single_column
Xdecoupling_cell_single_column_11 Vout VSUBS decoupling_cell_single_column
Xdecoupling_cell_single_column_23 Vout VSUBS decoupling_cell_single_column
Xdecoupling_cell_single_column_12 Vout VSUBS decoupling_cell_single_column
Xdecoupling_cell_single_column_24 Vout VSUBS decoupling_cell_single_column
Xdecoupling_cell_single_column_13 Vout VSUBS decoupling_cell_single_column
Xdecoupling_cell_single_column_25 Vout VSUBS decoupling_cell_single_column
Xdecoupling_cell_single_column_14 Vout VSUBS decoupling_cell_single_column
Xdecoupling_cell_single_column_26 Vout VSUBS decoupling_cell_single_column
Xdecoupling_cell_single_column_15 Vout VSUBS decoupling_cell_single_column
Xdecoupling_cell_single_column_27 Vout VSUBS decoupling_cell_single_column
Xdecoupling_cell_single_column_16 Vout VSUBS decoupling_cell_single_column
.ends

.subckt sky130_fd_pr__pfet_01v8_A7FR94 a_n183_n100# a_n125_n197# a_125_n100# w_n321_n319#
X0 a_125_n100# a_n125_n197# a_n183_n100# w_n321_n319# sky130_fd_pr__pfet_01v8 ad=2.9e+11p pd=2.58e+06u as=2.9e+11p ps=2.58e+06u w=1e+06u l=1.25e+06u
.ends

.subckt sky130_fd_pr__pfet_01v8_YKSYY8 a_125_n500# a_n491_n500# w_n629_n719# a_n433_n597#
+ a_433_n500# a_n183_n500# a_n125_n597# a_183_n597#
X0 a_n183_n500# a_n433_n597# a_n491_n500# w_n629_n719# sky130_fd_pr__pfet_01v8 ad=1.45e+12p pd=1.058e+07u as=1.45e+12p ps=1.058e+07u w=5e+06u l=1.25e+06u
X1 a_433_n500# a_183_n597# a_125_n500# w_n629_n719# sky130_fd_pr__pfet_01v8 ad=1.45e+12p pd=1.058e+07u as=1.45e+12p ps=1.058e+07u w=5e+06u l=1.25e+06u
X2 a_125_n500# a_n125_n597# a_n183_n500# w_n629_n719# sky130_fd_pr__pfet_01v8 ad=0p pd=0u as=0p ps=0u w=5e+06u l=1.25e+06u
.ends

.subckt sky130_fd_pr__nfet_01v8_CY273Z a_n358_n50# a_300_n50# a_n300_n138# a_n460_n224#
X0 a_300_n50# a_n300_n138# a_n358_n50# a_n460_n224# sky130_fd_pr__nfet_01v8 ad=1.45e+11p pd=1.58e+06u as=1.45e+11p ps=1.58e+06u w=500000u l=3e+06u
.ends

.subckt user_analog_project_wrapper gpio_analog[0] gpio_analog[10] gpio_analog[11]
+ gpio_analog[12] gpio_analog[13] gpio_analog[14] gpio_analog[15] gpio_analog[16]
+ gpio_analog[17] gpio_analog[1] gpio_analog[2] gpio_analog[3] gpio_analog[4] gpio_analog[5]
+ gpio_analog[6] gpio_analog[7] gpio_analog[8] gpio_analog[9] gpio_noesd[0] gpio_noesd[10]
+ gpio_noesd[11] gpio_noesd[12] gpio_noesd[13] gpio_noesd[14] gpio_noesd[15] gpio_noesd[16]
+ gpio_noesd[17] gpio_noesd[1] gpio_noesd[2] gpio_noesd[3] gpio_noesd[4] gpio_noesd[5]
+ gpio_noesd[6] gpio_noesd[7] gpio_noesd[8] gpio_noesd[9] io_analog[0] io_analog[10]
+ io_analog[1] io_analog[2] io_analog[3] io_analog[5] io_analog[7] io_analog[8] io_analog[9]
+ io_analog[4] io_analog[6] io_clamp_high[0] io_clamp_high[1] io_clamp_high[2] io_clamp_low[0]
+ io_clamp_low[1] io_clamp_low[2] io_in[0] io_in[10] io_in[11] io_in[12] io_in[13]
+ io_in[14] io_in[15] io_in[16] io_in[17] io_in[18] io_in[19] io_in[1] io_in[20] io_in[21]
+ io_in[22] io_in[23] io_in[24] io_in[25] io_in[26] io_in[2] io_in[3] io_in[4] io_in[5]
+ io_in[6] io_in[7] io_in[8] io_in[9] io_in_3v3[0] io_in_3v3[10] io_in_3v3[11] io_in_3v3[12]
+ io_in_3v3[13] io_in_3v3[14] io_in_3v3[15] io_in_3v3[16] io_in_3v3[17] io_in_3v3[18]
+ io_in_3v3[19] io_in_3v3[1] io_in_3v3[20] io_in_3v3[21] io_in_3v3[22] io_in_3v3[23]
+ io_in_3v3[24] io_in_3v3[25] io_in_3v3[26] io_in_3v3[2] io_in_3v3[3] io_in_3v3[4]
+ io_in_3v3[5] io_in_3v3[6] io_in_3v3[7] io_in_3v3[8] io_in_3v3[9] io_oeb[0] io_oeb[10]
+ io_oeb[11] io_oeb[12] io_oeb[13] io_oeb[14] io_oeb[15] io_oeb[16] io_oeb[17] io_oeb[18]
+ io_oeb[19] io_oeb[1] io_oeb[20] io_oeb[21] io_oeb[22] io_oeb[23] io_oeb[24] io_oeb[25]
+ io_oeb[26] io_oeb[2] io_oeb[3] io_oeb[4] io_oeb[5] io_oeb[6] io_oeb[7] io_oeb[8]
+ io_oeb[9] io_out[0] io_out[10] io_out[11] io_out[12] io_out[13] io_out[14] io_out[15]
+ io_out[16] io_out[17] io_out[18] io_out[19] io_out[1] io_out[20] io_out[21] io_out[22]
+ io_out[23] io_out[24] io_out[25] io_out[26] io_out[2] io_out[3] io_out[4] io_out[5]
+ io_out[6] io_out[7] io_out[8] io_out[9] la_data_in[0] la_data_in[100] la_data_in[101]
+ la_data_in[102] la_data_in[103] la_data_in[104] la_data_in[105] la_data_in[106]
+ la_data_in[107] la_data_in[108] la_data_in[109] la_data_in[10] la_data_in[110] la_data_in[111]
+ la_data_in[112] la_data_in[113] la_data_in[114] la_data_in[115] la_data_in[116]
+ la_data_in[117] la_data_in[118] la_data_in[119] la_data_in[11] la_data_in[120] la_data_in[121]
+ la_data_in[122] la_data_in[123] la_data_in[124] la_data_in[125] la_data_in[126]
+ la_data_in[127] la_data_in[12] la_data_in[13] la_data_in[14] la_data_in[15] la_data_in[16]
+ la_data_in[17] la_data_in[18] la_data_in[19] la_data_in[1] la_data_in[20] la_data_in[21]
+ la_data_in[22] la_data_in[23] la_data_in[24] la_data_in[25] la_data_in[26] la_data_in[27]
+ la_data_in[28] la_data_in[29] la_data_in[2] la_data_in[30] la_data_in[31] la_data_in[32]
+ la_data_in[33] la_data_in[34] la_data_in[35] la_data_in[36] la_data_in[37] la_data_in[38]
+ la_data_in[39] la_data_in[3] la_data_in[40] la_data_in[41] la_data_in[42] la_data_in[43]
+ la_data_in[44] la_data_in[45] la_data_in[46] la_data_in[47] la_data_in[48] la_data_in[49]
+ la_data_in[4] la_data_in[50] la_data_in[51] la_data_in[52] la_data_in[53] la_data_in[54]
+ la_data_in[55] la_data_in[56] la_data_in[57] la_data_in[58] la_data_in[59] la_data_in[5]
+ la_data_in[60] la_data_in[61] la_data_in[62] la_data_in[63] la_data_in[64] la_data_in[65]
+ la_data_in[66] la_data_in[67] la_data_in[68] la_data_in[69] la_data_in[6] la_data_in[70]
+ la_data_in[71] la_data_in[72] la_data_in[73] la_data_in[74] la_data_in[75] la_data_in[76]
+ la_data_in[77] la_data_in[78] la_data_in[79] la_data_in[7] la_data_in[80] la_data_in[81]
+ la_data_in[82] la_data_in[83] la_data_in[84] la_data_in[85] la_data_in[86] la_data_in[87]
+ la_data_in[88] la_data_in[89] la_data_in[8] la_data_in[90] la_data_in[91] la_data_in[92]
+ la_data_in[93] la_data_in[94] la_data_in[95] la_data_in[96] la_data_in[97] la_data_in[98]
+ la_data_in[99] la_data_in[9] la_data_out[0] la_data_out[100] la_data_out[101] la_data_out[102]
+ la_data_out[103] la_data_out[104] la_data_out[105] la_data_out[106] la_data_out[107]
+ la_data_out[108] la_data_out[109] la_data_out[10] la_data_out[110] la_data_out[111]
+ la_data_out[112] la_data_out[113] la_data_out[114] la_data_out[115] la_data_out[116]
+ la_data_out[117] la_data_out[118] la_data_out[119] la_data_out[11] la_data_out[120]
+ la_data_out[121] la_data_out[122] la_data_out[123] la_data_out[124] la_data_out[125]
+ la_data_out[126] la_data_out[127] la_data_out[12] la_data_out[13] la_data_out[14]
+ la_data_out[15] la_data_out[16] la_data_out[17] la_data_out[18] la_data_out[19]
+ la_data_out[1] la_data_out[20] la_data_out[21] la_data_out[22] la_data_out[23] la_data_out[24]
+ la_data_out[25] la_data_out[26] la_data_out[27] la_data_out[28] la_data_out[29]
+ la_data_out[2] la_data_out[30] la_data_out[31] la_data_out[32] la_data_out[33] la_data_out[34]
+ la_data_out[35] la_data_out[36] la_data_out[37] la_data_out[38] la_data_out[39]
+ la_data_out[3] la_data_out[40] la_data_out[41] la_data_out[42] la_data_out[43] la_data_out[44]
+ la_data_out[45] la_data_out[46] la_data_out[47] la_data_out[48] la_data_out[49]
+ la_data_out[4] la_data_out[50] la_data_out[51] la_data_out[52] la_data_out[53] la_data_out[54]
+ la_data_out[55] la_data_out[56] la_data_out[57] la_data_out[58] la_data_out[59]
+ la_data_out[5] la_data_out[60] la_data_out[61] la_data_out[62] la_data_out[63] la_data_out[64]
+ la_data_out[65] la_data_out[66] la_data_out[67] la_data_out[68] la_data_out[69]
+ la_data_out[6] la_data_out[70] la_data_out[71] la_data_out[72] la_data_out[73] la_data_out[74]
+ la_data_out[75] la_data_out[76] la_data_out[77] la_data_out[78] la_data_out[79]
+ la_data_out[7] la_data_out[80] la_data_out[81] la_data_out[82] la_data_out[83] la_data_out[84]
+ la_data_out[85] la_data_out[86] la_data_out[87] la_data_out[88] la_data_out[89]
+ la_data_out[8] la_data_out[90] la_data_out[91] la_data_out[92] la_data_out[93] la_data_out[94]
+ la_data_out[95] la_data_out[96] la_data_out[97] la_data_out[98] la_data_out[99]
+ la_data_out[9] la_oenb[0] la_oenb[100] la_oenb[101] la_oenb[102] la_oenb[103] la_oenb[104]
+ la_oenb[105] la_oenb[106] la_oenb[107] la_oenb[108] la_oenb[109] la_oenb[10] la_oenb[110]
+ la_oenb[111] la_oenb[112] la_oenb[113] la_oenb[114] la_oenb[115] la_oenb[116] la_oenb[117]
+ la_oenb[118] la_oenb[119] la_oenb[11] la_oenb[120] la_oenb[121] la_oenb[122] la_oenb[123]
+ la_oenb[124] la_oenb[125] la_oenb[126] la_oenb[127] la_oenb[12] la_oenb[13] la_oenb[14]
+ la_oenb[15] la_oenb[16] la_oenb[17] la_oenb[18] la_oenb[19] la_oenb[1] la_oenb[20]
+ la_oenb[21] la_oenb[22] la_oenb[23] la_oenb[24] la_oenb[25] la_oenb[26] la_oenb[27]
+ la_oenb[28] la_oenb[29] la_oenb[2] la_oenb[30] la_oenb[31] la_oenb[32] la_oenb[33]
+ la_oenb[34] la_oenb[35] la_oenb[36] la_oenb[37] la_oenb[38] la_oenb[39] la_oenb[3]
+ la_oenb[40] la_oenb[41] la_oenb[42] la_oenb[43] la_oenb[44] la_oenb[45] la_oenb[46]
+ la_oenb[47] la_oenb[48] la_oenb[49] la_oenb[4] la_oenb[50] la_oenb[51] la_oenb[52]
+ la_oenb[53] la_oenb[54] la_oenb[55] la_oenb[56] la_oenb[57] la_oenb[58] la_oenb[59]
+ la_oenb[5] la_oenb[60] la_oenb[61] la_oenb[62] la_oenb[63] la_oenb[64] la_oenb[65]
+ la_oenb[66] la_oenb[67] la_oenb[68] la_oenb[69] la_oenb[6] la_oenb[70] la_oenb[71]
+ la_oenb[72] la_oenb[73] la_oenb[74] la_oenb[75] la_oenb[76] la_oenb[77] la_oenb[78]
+ la_oenb[79] la_oenb[7] la_oenb[80] la_oenb[81] la_oenb[82] la_oenb[83] la_oenb[84]
+ la_oenb[85] la_oenb[86] la_oenb[87] la_oenb[88] la_oenb[89] la_oenb[8] la_oenb[90]
+ la_oenb[91] la_oenb[92] la_oenb[93] la_oenb[94] la_oenb[95] la_oenb[96] la_oenb[97]
+ la_oenb[98] la_oenb[99] la_oenb[9] user_clock2 user_irq[0] user_irq[1] user_irq[2]
+ vccd1 vccd2 vdda1 vdda2 vssa1 vssa2 vssd1 vssd2 wb_clk_i wb_rst_i wbs_ack_o wbs_adr_i[0]
+ wbs_adr_i[10] wbs_adr_i[11] wbs_adr_i[12] wbs_adr_i[13] wbs_adr_i[14] wbs_adr_i[15]
+ wbs_adr_i[16] wbs_adr_i[17] wbs_adr_i[18] wbs_adr_i[19] wbs_adr_i[1] wbs_adr_i[20]
+ wbs_adr_i[21] wbs_adr_i[22] wbs_adr_i[23] wbs_adr_i[24] wbs_adr_i[25] wbs_adr_i[26]
+ wbs_adr_i[27] wbs_adr_i[28] wbs_adr_i[29] wbs_adr_i[2] wbs_adr_i[30] wbs_adr_i[31]
+ wbs_adr_i[3] wbs_adr_i[4] wbs_adr_i[5] wbs_adr_i[6] wbs_adr_i[7] wbs_adr_i[8] wbs_adr_i[9]
+ wbs_cyc_i wbs_dat_i[0] wbs_dat_i[10] wbs_dat_i[11] wbs_dat_i[12] wbs_dat_i[13] wbs_dat_i[14]
+ wbs_dat_i[15] wbs_dat_i[16] wbs_dat_i[17] wbs_dat_i[18] wbs_dat_i[19] wbs_dat_i[1]
+ wbs_dat_i[20] wbs_dat_i[21] wbs_dat_i[22] wbs_dat_i[23] wbs_dat_i[24] wbs_dat_i[25]
+ wbs_dat_i[26] wbs_dat_i[27] wbs_dat_i[28] wbs_dat_i[29] wbs_dat_i[2] wbs_dat_i[30]
+ wbs_dat_i[31] wbs_dat_i[3] wbs_dat_i[4] wbs_dat_i[5] wbs_dat_i[6] wbs_dat_i[7] wbs_dat_i[8]
+ wbs_dat_i[9] wbs_dat_o[0] wbs_dat_o[10] wbs_dat_o[11] wbs_dat_o[12] wbs_dat_o[13]
+ wbs_dat_o[14] wbs_dat_o[15] wbs_dat_o[16] wbs_dat_o[17] wbs_dat_o[18] wbs_dat_o[19]
+ wbs_dat_o[1] wbs_dat_o[20] wbs_dat_o[21] wbs_dat_o[22] wbs_dat_o[23] wbs_dat_o[24]
+ wbs_dat_o[25] wbs_dat_o[26] wbs_dat_o[27] wbs_dat_o[28] wbs_dat_o[29] wbs_dat_o[2]
+ wbs_dat_o[30] wbs_dat_o[31] wbs_dat_o[3] wbs_dat_o[4] wbs_dat_o[5] wbs_dat_o[6]
+ wbs_dat_o[7] wbs_dat_o[8] wbs_dat_o[9] wbs_sel_i[0] wbs_sel_i[1] wbs_sel_i[2] wbs_sel_i[3]
+ wbs_stb_i wbs_we_i
Xsky130_fd_pr__res_xhigh_po_5p73_2AHZHE_1 vssa1 gpio_analog[14] vssa1 sky130_fd_pr__res_xhigh_po_5p73_2AHZHE
Xsky130_fd_pr__res_xhigh_po_5p73_2AHZHE_2 vssa1 gpio_analog[15] vssa1 sky130_fd_pr__res_xhigh_po_5p73_2AHZHE
Xsky130_fd_pr__res_xhigh_po_5p73_2AHZHE_3 vssa1 gpio_analog[16] vssa1 sky130_fd_pr__res_xhigh_po_5p73_2AHZHE
Xsky130_fd_pr__res_xhigh_po_5p73_2AHZHE_4 vssa1 gpio_analog[17] vssa1 sky130_fd_pr__res_xhigh_po_5p73_2AHZHE
Xsky130_fd_pr__nfet_01v8_SBZDCA_0 m1_553779_152688# vssa1 gpio_analog[0] m1_553779_152688#
+ vssa1 vssa1 sky130_fd_pr__nfet_01v8_SBZDCA
Xsky130_fd_pr__nfet_01v8_UBS3CQ_0 gpio_analog[1] m1_553779_152358# vssa1 vssa1 sky130_fd_pr__nfet_01v8_UBS3CQ
Xsky130_fd_pr__nfet_01v8_UBS3CQ_1 gpio_analog[1] m1_553779_152688# vssa1 m1_553779_152358#
+ sky130_fd_pr__nfet_01v8_UBS3CQ
Xswitched_cap_0 vdda1 vssa1 io_analog[5] gpio_analog[6] gpio_analog[8] gpio_analog[7]
+ gpio_analog[5] switched_cap
Xsky130_fd_pr__nfet_01v8_DPBXBZ_0 m1_553779_152688# m1_553779_152358# vdda1 m1_553779_152688#
+ vdda1 m1_553779_152688# vssa1 m1_553779_152358# m1_553779_152358# m1_553779_152688#
+ sky130_fd_pr__nfet_01v8_DPBXBZ
Xmirrors_0 io_analog[4] vssa1 io_analog[5] io_analog[3] io_analog[7] mirrors
Xsky130_fd_pr__pfet_01v8_UJR9GH_0 gpio_analog[0] gpio_analog[0] vdda1 m1_553779_152688#
+ gpio_analog[2] m1_553779_152688# m1_553779_152688# vdda1 m1_553779_152688# m1_553779_152688#
+ m1_553779_152688# vdda1 gpio_analog[0] gpio_analog[0] sky130_fd_pr__pfet_01v8_UJR9GH
XLDO_0 gpio_analog[6] io_analog[1] vssa1 io_analog[2] LDO
Xpwm_lower_0 vssa1 io_analog[0] vdda1 gpio_analog[6] io_analog[5] pwm_lower
Xsky130_fd_pr__diode_pd2nw_11v0_K4SERG_0 vssa1 gpio_analog[7] sky130_fd_pr__diode_pd2nw_11v0_K4SERG
Xsky130_fd_pr__diode_pd2nw_11v0_K4SERG_1 vssa1 gpio_analog[8] sky130_fd_pr__diode_pd2nw_11v0_K4SERG
Xsky130_fd_pr__diode_pd2nw_11v0_K4SERG_2 vssa1 gpio_analog[6] sky130_fd_pr__diode_pd2nw_11v0_K4SERG
Xdecoupling_cell_0 vssa1 io_analog[5] decoupling_cell
Xsky130_fd_pr__diode_pd2nw_11v0_K4SERG_3 vssa1 gpio_analog[5] sky130_fd_pr__diode_pd2nw_11v0_K4SERG
Xsky130_fd_pr__pfet_01v8_A7FR94_0 m1_553804_153575# gpio_analog[1] m1_553779_152688#
+ gpio_analog[2] sky130_fd_pr__pfet_01v8_A7FR94
Xsky130_fd_pr__pfet_01v8_A7FR94_1 vdda1 gpio_analog[1] m1_553804_153575# gpio_analog[2]
+ sky130_fd_pr__pfet_01v8_A7FR94
Xsky130_fd_pr__diode_pd2nw_11v0_K4SERG_4 vssa1 gpio_analog[10] sky130_fd_pr__diode_pd2nw_11v0_K4SERG
Xsky130_fd_pr__diode_pd2nw_11v0_K4SERG_5 vssa1 gpio_analog[11] sky130_fd_pr__diode_pd2nw_11v0_K4SERG
Xsky130_fd_pr__pfet_01v8_YKSYY8_0 m1_553804_153575# m1_553804_153575# gpio_analog[2]
+ m1_553779_152688# vssa1 vssa1 m1_553779_152688# m1_553779_152688# sky130_fd_pr__pfet_01v8_YKSYY8
Xsky130_fd_pr__nfet_01v8_CY273Z_0 gpio_analog[13] vssa1 gpio_analog[9] vssa1 sky130_fd_pr__nfet_01v8_CY273Z
Xsky130_fd_pr__nfet_01v8_CY273Z_1 gpio_analog[12] vssa1 gpio_analog[4] vssa1 sky130_fd_pr__nfet_01v8_CY273Z
Xsky130_fd_pr__diode_pd2nw_11v0_K4SERG_6 vssa1 gpio_analog[12] sky130_fd_pr__diode_pd2nw_11v0_K4SERG
Xsky130_fd_pr__nfet_01v8_CY273Z_2 gpio_analog[11] vssa1 gpio_analog[3] vssa1 sky130_fd_pr__nfet_01v8_CY273Z
Xsky130_fd_pr__diode_pd2nw_11v0_K4SERG_8 vssa1 gpio_analog[9] sky130_fd_pr__diode_pd2nw_11v0_K4SERG
Xsky130_fd_pr__diode_pd2nw_11v0_K4SERG_7 vssa1 gpio_analog[13] sky130_fd_pr__diode_pd2nw_11v0_K4SERG
Xsky130_fd_pr__nfet_01v8_CY273Z_3 gpio_analog[10] vssa1 gpio_analog[2] vssa1 sky130_fd_pr__nfet_01v8_CY273Z
Xsky130_fd_pr__diode_pd2nw_11v0_K4SERG_9 vssa1 gpio_analog[4] sky130_fd_pr__diode_pd2nw_11v0_K4SERG
Xsky130_fd_pr__diode_pd2nw_11v0_K4SERG_10 vssa1 gpio_analog[3] sky130_fd_pr__diode_pd2nw_11v0_K4SERG
Xsky130_fd_pr__diode_pd2nw_11v0_K4SERG_11 vssa1 gpio_analog[2] sky130_fd_pr__diode_pd2nw_11v0_K4SERG
Xsky130_fd_pr__diode_pd2nw_11v0_K4SERG_12 vssa1 gpio_analog[1] sky130_fd_pr__diode_pd2nw_11v0_K4SERG
Xsky130_fd_pr__diode_pd2nw_11v0_K4SERG_13 vssa1 gpio_analog[0] sky130_fd_pr__diode_pd2nw_11v0_K4SERG
R0 m1_145394_553901# io_analog[9] sky130_fd_pr__res_generic_m3 w=2.5e+07u l=2.3145e+07u
R1 m1_145394_553901# io_analog[8] sky130_fd_pr__res_generic_m3 w=2.5e+07u l=2.3145e+07u
R2 gpio_analog[3] vssa1 sky130_fd_pr__res_generic_m1 w=370000u l=2.795e+06u
R3 m1_145394_553901# io_analog[10] sky130_fd_pr__res_generic_m3 w=2.5e+07u l=2.3145e+07u
.ends
